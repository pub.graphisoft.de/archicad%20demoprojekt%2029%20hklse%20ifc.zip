Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option: [Keine IfcSpaces: On], Option: [Keine Kabel: On], Option [Gebäude: Off], Option [Elektrotechnik: Off], Option [Heizung: On], Option [Sanitär: Off], Option [Brandschutz: Off], Option [Kälte: Off], Option [Klima/Lüftung: Off], Option [Provision for Void: Off]
File name: 20250704_Demoprojekt_HZ.ifc
Time: 2025-07-07T17:31:31
Author: onedr
Organization: 123
Written by: DDS_IFC v3.0
Made in: DDScad MEP Version 20 x64 build 20/11-2024
Authorization: DDS

# IfcProject, Archicad Demoprojekt Bürogebäude
Description: Demodatei eines Bürogebäudes mit Verkaufsfläche

# IfcSite, Grundstück
RefLatitude: 51, 47, 22, 999999; RefLongitude: 7, 37, 12, 999999; RefElevation: 62 m
Pset_LandRegistration - IsPermanentID: no

# IfcBuilding, DDScad-Demoprojekt-Buero-18
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (6)
In: DDScad-Demoprojekt-Buero-18
Name | Description | Elevation (m)
Obergeschoss | Obergeschoss | 4.4
Erdgeschoss | Erdgeschoss | 0
Dachaufsicht | Dachaufsicht | 13.2
Obergeschoss | Obergeschoss | 8.8
Untergeschoss | Untergeschoss | -3.5
Fundament | Fundament | -5.3

# IfcBoiler: Kompaktstation 2 HK + WW 1000 kW, -19
In: Untergeschoss
Type - PredefinedType: WATER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GF840_1000; Manufacturer: DDScad

# IfcBoiler: Puffer-Brauchwasserspeicher 500 Liter, mit Wärmedämmung
In: Untergeschoss
Type - PredefinedType: WATER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 370/500; Manufacturer: DDScad

# IfcBuildingElementProxy: Hydraulische Schaltung
In: Untergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HU001; Manufacturer: DDScad

# IfcCoil: Split Gerät, in abgehängter Decke_660x660x150 (15)
In: Obergeschoss
Type - PredefinedType: WATERCOOLINGCOIL
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-210323144023; Manufacturer: DDS
HK_Test - Lxbxh: 660 mm x 150 mm x 660 mm

# IfcDistributionChamberElement: Roth Heizkreisverteiler Messing HKV 1" mit DFA, DFM 0-4l/min In direkter Anschluss Out Verschraubung Nr of outlets 13 (2)
In: Erdgeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: dfbf7a7e-a6b8-4; Manufacturer: Roth-UFH

# IfcDistributionChamberElement: Roth Heizkreisverteiler Messing HKV 1" mit DFA, DFM 0-4l/min In direkter Anschluss Out Verschraubung Nr of outlets 14 (2)
In: Erdgeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 5d18dd2d-7e58-4; Manufacturer: Roth-UFH
Name

-1

# IfcDistributionPort (3668)
FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name | NominalDiameter (m)
858 x  | 0.02
1660 x  | 0.032
1102 x  | 0.025
48 x  | 0.04

# IfcPipeFitting: Cu Abzweig 90° 22/22/22 (2)
In: Erdgeschoss
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-308; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE

# IfcPipeFitting: Cu Abzweig 90° 28/28/28 (28)
In: Obergeschoss
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-311; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name
6 x -01
4 x -199
6 x -00
8 x -03
-04 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x -04
-04 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro

# IfcPipeFitting: Cu Abzweig 90° 35/22/35 (32)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-312; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -1 | Erdgeschoss
20 x -05 | Obergeschoss
2 x -04 | Obergeschoss
6 x -06 | Obergeschoss
-05 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
-05 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro

# IfcPipeFitting: Cu Abzweig 90° 35/28/35 (2)
In: Erdgeschoss
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-313; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE

# IfcPipeFitting: Cu Abzweig 90° 35/35/35 (42)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-314; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
16 x -02 | Obergeschoss
2 x -05 | Untergeschoss
4 x -1 | Erdgeschoss
8 x -03 | Obergeschoss
4 x -07 | Obergeschoss
6 x -01 | Obergeschoss
2 x -199 | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen 30° 42 x 2 (2)
In: Untergeschoss
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000042030; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.523599 rad; BendRadius: 0.06 m

# IfcPipeFitting: Cu Fitting Bogen 45° 22 x 1 (68)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000022045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.03 m
Name | In
8 x -0 | Erdgeschoss
16 x -09 | Obergeschoss
8 x -15 | Obergeschoss
4 x -12 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
8 x -07 | Obergeschoss
8 x -16 | Obergeschoss
12 x -06 | Obergeschoss
4 x -12 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting

# IfcPipeFitting: Cu Fitting Bogen 45° 28 x 1,5 (64)
In: Obergeschoss
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000028045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.0375 m
Name
24 x -02
16 x -191
16 x -193
4 x -03 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
4 x -03 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting

# IfcPipeFitting: Cu Fitting Bogen 45° 35 x 1,5 (68)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000035045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.048 m
Name | In
16 x -198 | Obergeschoss
4 x -1 | Erdgeschoss
16 x -195 | Obergeschoss
12 x -193 | Obergeschoss
4 x -197 | Obergeschoss
8 x -03 | Obergeschoss
8 x -01 | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen 90° 22 x 1 (86)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000022090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.03 m
Name | In
16 x -09 | Obergeschoss
6 x -14 | Erdgeschoss
6 x -16 | Erdgeschoss
-19 | Erdgeschoss
3 x -18 | Erdgeschoss
-17 | Erdgeschoss
2 x -15 | Erdgeschoss
-0 | Erdgeschoss
4 x -15 | Obergeschoss
4 x -12 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
12 x -06 | Obergeschoss
8 x -08 | Obergeschoss
12 x -16 | Obergeschoss
3 x -11 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
4 x -12 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
3 x -11 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro

# IfcPipeFitting: Cu Fitting Bogen 90° 28 x 1,5 (118)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000028090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.0375 m
Name | In
6 x -05 | Obergeschoss
14 x -03 | Obergeschoss
2 x -194 | Untergeschoss
4 x -192 | Untergeschoss
2 x -193 | Untergeschoss
52 x -191 | Obergeschoss
2 x  | Erdgeschoss
24 x -02 | Obergeschoss
-05 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
10 x -192 | Obergeschoss
-05 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro

# IfcPipeFitting: Cu Fitting Bogen 90° 35 x 1,5 (184)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000035090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.048 m
Name | In
28 x -195 | Obergeschoss
31 x -198 | Obergeschoss
3 x -194 | Obergeschoss
4 x -187 | Untergeschoss
-185 | Untergeschoss
14 x -184 | Untergeschoss
8 x -186 | Untergeschoss
12 x -197 | Obergeschoss
13 x -1 | Erdgeschoss
5 x -191 | Obergeschoss
8 x  | Erdgeschoss
26 x -193 | Obergeschoss
20 x -09 | Obergeschoss
4 x -05 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x -05 | Obergeschoss
4 x -05 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
-192 | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen 90° 42 x 2 (9)
In: Untergeschoss
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000042090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.06 m
Name
2 x -184
5 x -183
2 x -182

# IfcPipeSegment: Kupferrohre in Stangen 5 m, 22 x 1 mm (224)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.001 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209005; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.02 m; InnerDiameter: 0.02 m; OuterDiameter: 0.022 m
Name | In | Gradient | Length (m)
2 x  | Obergeschoss | 8.70788e-31 | 0.0694385
9 x  | Obergeschoss | 0 | 0.092
 | Erdgeschoss | 3.75339e-32 | 0.118527
 | Erdgeschoss | 0
2 x  | Erdgeschoss | 1 | 1.115
 | Erdgeschoss | 7.79634e-17 | 0.414648
 | Erdgeschoss | 9.60302e-34 | 0.08
 | Erdgeschoss | 7.79634e-17 | 0.648062
2 x  | Obergeschoss | 5.02037e-16 | 0.132624
 | Erdgeschoss | 7.79634e-17 | 0.238584
 | Erdgeschoss | 3.75339e-32 | 0.00219044
2 x  | Erdgeschoss | 1 | 0.04
 | Erdgeschoss | 0 | 4.48373
 | Erdgeschoss | 1.12486e-32 | 4.27298
 | Erdgeschoss | 7.79634e-17 | 0.111839
2 x  | Erdgeschoss | 1 | 0.265
26 x  | Obergeschoss | 1 | 0.14
26 x  | Obergeschoss | 0.5 | 0.125054
 | Erdgeschoss | 0 | 0.160808
2 x  | Obergeschoss | 7.0679e-17 | 0.0519259
 | Erdgeschoss | 0 | 0.24467
4 x  | Erdgeschoss | 0.5 | 0.125054
 | Erdgeschoss | 0 | 9.83199
 | Erdgeschoss | 0 | 0.0585504
 | Erdgeschoss | 0 | 0.162808
 | Erdgeschoss | 0 | 0.19683
 | Erdgeschoss | 0 | 0.241262
 | Erdgeschoss | 0 | 0.360064
 | Erdgeschoss | 0 | 10.0952
 | Erdgeschoss | 3.13878e-32 | 4.05473
 | Erdgeschoss | 0 | 0.181036
 | Erdgeschoss | 0 | 3.843
 | Erdgeschoss | 6.33945e-17 | 0.1525
2 x  | Obergeschoss | 4.29375e-15 | 0.0519259
2 x  | Obergeschoss | 5.02037e-16 | 1.67776
2 x  | Obergeschoss | 8.70788e-31 | 0.787097
2 x  | Obergeschoss | 0 | 0.157492
2 x  | Obergeschoss | 9.54777e-33 | 0.102346
2 x  | Obergeschoss | 4.31142e-15 | 0.0989625
 | Obergeschoss | 0 | 0.250706 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
3 x  | Obergeschoss | 1 | 0.14 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x  | Obergeschoss | 6.33945e-17 | 0.794697
2 x  | Obergeschoss | 0 | 0.396183
2 x  | Obergeschoss | 9.54777e-33 | 0.716095
 | Obergeschoss | 6.33945e-17 | 0.112412 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x  | Obergeschoss | 0 | 0.0854848
 | Obergeschoss | 3.30886e-32 | 1.6728 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x  | Obergeschoss | 6.33945e-17 | 0.881702
2 x  | Obergeschoss | 0 | 0.210902
2 x  | Obergeschoss | 1.45689e-17 | 0.00189804
2 x  | Obergeschoss | 1.45689e-17 | 0.00917447
2 x  | Obergeschoss | 4.34676e-15 | 0.0534721
2 x  | Obergeschoss | 6.33945e-17 | 0.187333
2 x  | Obergeschoss | 6.33945e-17 | 0.0832238
2 x  | Obergeschoss | 0 | 0.234162
2 x  | Obergeschoss | 9.54777e-33 | 0.108855
 | Obergeschoss | 7.54942e-31 | 0.0101438
 | Obergeschoss | 7.54942e-31 | 0.0106396
2 x  | Obergeschoss | 0 | 0.203684
2 x  | Obergeschoss | 6.43395e-16 | 0.130783
 | Obergeschoss | 6.33945e-17 | 0.885179
2 x  | Obergeschoss | 6.43395e-16 | 1.48203
2 x  | Obergeschoss | 8.70788e-31 | 0.749343
3 x  | Obergeschoss | 1 | 0.14 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 6.70202e-32 | 0.0814202 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 0 | 0.214401
2 x  | Obergeschoss | 0 | 0.289948
2 x  | Obergeschoss | 5.02037e-16 | 0.0728668
 | Obergeschoss | 0 | 1.85359 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 8.70788e-31 | 0.109619
 | Obergeschoss | 6.70202e-32 | 1.41596 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 5.02037e-16 | 1.73995
2 x  | Obergeschoss | 0 | 0.279149
 | Obergeschoss | 7.0679e-17 | 0.092 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 0.5 | 0.125054 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 3.30886e-32 | 1.6728 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 6.33945e-17 | 0.74655 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 0 | 0.17 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 8.87021e-15 | 0.0519259 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 0 | 0.377709 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 0 | 0.250706 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 3.30886e-32 | 0.140014 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 6.33945e-17 | 0.112412 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 7.79634e-17 | 0.150183
2 x  | Obergeschoss | 1.70082e-33 | 0.357159
 | Obergeschoss | 7.79634e-17 | 1.66263
 | Obergeschoss | 0 | 1.66263
 | Obergeschoss | 0 | 0.26467
2 x  | Obergeschoss | 0 | 0.262804
2 x  | Obergeschoss | 8.62941e-31 | 0.00854757
3 x  | Obergeschoss | 4.25841e-15 | 0.0534721
 | Obergeschoss | 0 | 0.194676
2 x  | Obergeschoss | 8.62941e-31 | 0.0196301
2 x  | Obergeschoss | 9.54777e-33 | 0.531777
2 x  | Obergeschoss | 4.31142e-15 | 0.0430193
 | Obergeschoss | 0 | 0.204018
2 x  | Obergeschoss | 0 | 0.214866
 | Obergeschoss | 6.33945e-17 | 0.0894567
2 x  | Obergeschoss | 0 | 0.119237
 | Obergeschoss | 3.30886e-32 | 0.140014 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 0 | 0.677709 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 6.33945e-17 | 0.74655 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x  | Obergeschoss | 0.5 | 0.125054 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 7.0679e-17 | 0.092 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 0 | 0.17 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 0 | 1.85359 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Erdgeschoss | 6.33945e-17 | 0.0578444
 | Obergeschoss | 8.87021e-15 | 0.0519259 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 6.70202e-32 | 1.41596 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 6.70202e-32 | 0.0814202 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 0 | 0.56467

# IfcPipeSegment: Kupferrohre in Stangen 5 m, 28 x 1,5 mm (288)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0015 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209006; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.025 m; InnerDiameter: 0.025 m; OuterDiameter: 0.028 m
Name | In | Gradient | Length (m)
2 x  | Obergeschoss | 9.54777e-33 | 0.157748
4 x  | Obergeschoss | 1 | 3.981
2 x  | Untergeschoss | 1 | 0.1625
 | Untergeschoss | 3.89817e-17 | 7.05016
 | Untergeschoss | 0 | 4.48593
 | Untergeschoss | 7.79634e-17 | 15.6947
 | Untergeschoss | 0 | 4.55462
2 x  | Untergeschoss | 1 | 0.1425
 | Untergeschoss | 3.89817e-17 | 7.25655
 | Untergeschoss | 7.79634e-17 | 15.9006
11 x  | Obergeschoss | 0.5 | 0.117426
 | Obergeschoss | 0 | 0.139961
 | Obergeschoss | 1
 | Obergeschoss | 6.33945e-17 | 7.10543e-15
 | Obergeschoss | 4.46108e-22 | 4.29153e-07
2 x  | Obergeschoss | 3.13878e-32 | 0.199386
 | Obergeschoss | 1.55927e-16 | 0.089267
2 x  | Obergeschoss | 0 | 0.0699735
 | Obergeschoss | 8.83487e-17 | 0.518889
 | Obergeschoss | 0.5 | 0.1341
2 x  | Obergeschoss | 0 | 0.42961
15 x  | Obergeschoss | 1 | 0.075
2 x  | Obergeschoss | 0 | 2.79308
2 x  | Obergeschoss | 1.23688e-16 | 3.67627
3 x  | Obergeschoss | 2.92149e-33 | 7.10543e-15
2 x  | Obergeschoss | 1.06018e-16 | 0.085
2 x  | Obergeschoss | 7.79634e-17 | 0.118326
 | Obergeschoss | 0.5 | 0.103837
 | Obergeschoss | 8.83487e-17 | 11.4725
 | Obergeschoss | 3.13878e-32 | 0.746684
4 x  | Obergeschoss | 1 | 0.0250318
 | Obergeschoss | 0 | 0.191734
2 x  | Obergeschoss | 0 | 0.175
2 x  | Obergeschoss | 4.08041e-31 | 0.656093
 | Obergeschoss | 0 | 0.0163206
2 x  | Obergeschoss | 0 | 0.0394212
 | Obergeschoss | 7.79634e-17 | 2.04066
 | Obergeschoss | 7.79634e-17 | 2.00928
10 x  | Obergeschoss | 1 | 0.025
2 x  | Obergeschoss | 2.42979e-09 | 0.085
 | Obergeschoss | 6.33945e-17 | 0.0192195
 | Obergeschoss | 6.33945e-17 | 0.0177908
 | Obergeschoss | 9.25895e-15 | 0.11729
2 x  | Erdgeschoss | 1 | 4.4
2 x  | Obergeschoss | 1 | 0.2625
2 x  | Obergeschoss | 1 | 0.0435
2 x  | Obergeschoss | 4.08041e-31 | 0.0884892
 | Erdgeschoss | 1 | 0.3885
 | Erdgeschoss | 1 | 0.4885
 | Erdgeschoss | 0 | 0.259416
 | Erdgeschoss | 0 | 0.186916
 | Obergeschoss | 0 | 0.0562195
 | Obergeschoss | 1.16945e-16 | 0.0391057
2 x  | Obergeschoss | 1.55927e-16 | 0.0815596
 | Obergeschoss | 1.16945e-16 | 6.98549
 | Obergeschoss | 7.84694e-31 | 1.44843
 | Obergeschoss | 3.13878e-32 | 0.0604538
2 x  | Obergeschoss | 7.79634e-17 | 0.349601
 | Obergeschoss | 7.79634e-17 | 16.606
2 x  | Obergeschoss | 9.54777e-33 | 0.15025
 | Obergeschoss | 0
 | Obergeschoss | 3.53395e-17 | 0.358701
 | Obergeschoss | 2.18376e-15 | 0.141812
14 x  | Obergeschoss | 0.5 | 0.122376
 | Obergeschoss | 3.53395e-17 | 0.092
2 x  | Obergeschoss | 0 | 0.402023
 | Obergeschoss | 3.53395e-17 | 10.5068
2 x  | Obergeschoss | 2.18376e-15 | 0.102896
 | Obergeschoss | 1.76697e-17 | 4.86334
 | Obergeschoss | 3.53395e-17 | 4.50612
2 x  | Obergeschoss | 0 | 0.771135
 | Obergeschoss | 9.47926e-09 | 0.0345045 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x  | Obergeschoss | 0.5 | 0.117426 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x  | Obergeschoss | 0 | 0.063357
2 x  | Obergeschoss | 0 | 0.159964
2 x  | Obergeschoss | 3.89817e-17 | 0.299017
2 x  | Obergeschoss | 7.79634e-17 | 4.53136
 | Obergeschoss | 8.50411e-33 | 8.88178e-16
 | Obergeschoss | 7.79634e-17 | 4.62348 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 0 | 0.085 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x  | Obergeschoss | 7.97088e-10 | 0.116132
2 x  | Obergeschoss | 7.79634e-17 | 7.83535
2 x  | Obergeschoss | 3.89817e-17 | 0.300742
2 x  | Obergeschoss | 0 | 0.114819
2 x  | Obergeschoss | 3.89817e-17 | 3.59347
2 x  | Obergeschoss | 2.18376e-15 | 0.578239
 | Obergeschoss | 2.92149e-33 | 3.55271e-15
2 x  | Obergeschoss | 7.0679e-17 | 0.150068
 | Obergeschoss | 0 | 0.00946699
 | Obergeschoss | 1.76697e-17 | 4.56334
2 x  | Obergeschoss | 7.79634e-17 | 0.0725247
 | Obergeschoss | 3.53395e-17 | 9.91002
2 x  | Obergeschoss | 0.5 | 0.117426 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 7.79634e-17 | 0.108701
2 x  | Obergeschoss | 7.97088e-10 | 0.351432
 | Obergeschoss | 9.47926e-09 | 0.0345045 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 0 | 0.085 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 7.79634e-17 | 4.62348 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 1.76697e-17 | 11.111
2 x  | Obergeschoss | 0 | 0.111838
2 x  | Obergeschoss | 6.33945e-17 | 0.0787327
2 x  | Obergeschoss | 0 | 0.0858238
2 x  | Obergeschoss | 3.89817e-17 | 3.3636
2 x  | Obergeschoss | 1.56939e-32 | 0.158883
2 x  | Obergeschoss | 7.79634e-17 | 0.117215
 | Obergeschoss | 7.79634e-17 | 0.33185 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 6.33945e-17 | 0.229266
2 x  | Obergeschoss | 0 | 0.085
 | Obergeschoss | 3.53395e-17 | 4.20612
2 x  | Obergeschoss | 3.13878e-32 | 0.100736
2 x  | Obergeschoss | 6.33945e-17 | 4.29153e-07
 | Obergeschoss | 6.02853e-10 | 0.598486
 | Obergeschoss | 3.53395e-17 | 10.21
 | Obergeschoss | 2.42979e-09 | 0.139961
 | Obergeschoss | 7.79634e-17 | 0.00946699
2 x  | Obergeschoss | 6.33945e-17 | 0
2 x  | Obergeschoss | 3.13878e-32 | 0.348328
 | Obergeschoss | 6.02853e-10 | 0.0608052
 | Obergeschoss | 7.79634e-17 | 8.2485
 | Obergeschoss | 7.79634e-17 | 3.43602
 | Obergeschoss | 0 | 0.0924971
 | Obergeschoss | 3.84961e-09 | 0.107679
 | Obergeschoss | 6.33945e-17 | 0.0797705
 | Obergeschoss | 8.50411e-33 | 4.29153e-07
 | Obergeschoss | 6.33945e-17 | 0.419955
 | Obergeschoss | 0 | 0.101091
 | Obergeschoss | 1.76697e-17 | 10.811
 | Obergeschoss | 1.55927e-16 | 0.0893305
 | Obergeschoss | 0 | 0.108701
 | Obergeschoss | 3.13878e-32 | 0.74665
 | Obergeschoss | 1.56939e-32 | 0.235079
 | Obergeschoss | 0 | 0.437685
 | Obergeschoss | 0.00000123404 | 16.361
2 x  | Obergeschoss | 1 | 0.03
 | Obergeschoss | 7.79634e-17 | 0.085
2 x  | Obergeschoss | 7.79634e-17 | 0.650705
 | Obergeschoss | 7.79634e-17 | 0.0857063
 | Obergeschoss | 2.42979e-09 | 2.13324
 | Obergeschoss | 6.33945e-17 | 3.23019
 | Obergeschoss | 6.33945e-17 | 7.22141
2 x  | Obergeschoss | 7.79634e-17 | 0.0768861
2 x  | Obergeschoss | 0 | 0.203107
 | Obergeschoss | 1.33359e-32 | 7.10543e-15
 | Obergeschoss | 1.16945e-16 | 0.132848
 | Obergeschoss | 7.79634e-17 | 0.0321928
2 x  | Obergeschoss | 5.30092e-17 | 0.092
 | Obergeschoss | 1.55927e-16 | 0.0604538
 | Obergeschoss | 1.16945e-16 | 9.56676
 | Obergeschoss | 0 | 1.44843
 | Obergeschoss | 7.79634e-17 | 0.277393
 | Obergeschoss | 7.79634e-17 | 0.141812
2 x  | Obergeschoss | 7.97089e-10 | 0.342043
2 x  | Obergeschoss | 9.47924e-09 | 0.0345045
 | Obergeschoss | 0 | 16.606
 | Obergeschoss | 1.16945e-16 | 0.133325
 | Obergeschoss | 7.79634e-17 | 0.33185 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 1.16945e-16 | 9.26151
2 x  | Obergeschoss | 0 | 0.0961313
2 x  | Obergeschoss | 7.97089e-10 | 0.125521
 | Obergeschoss | 6.27756e-32 | 2.13324
 | Obergeschoss | 1.16945e-16 | 6.96996
 | Obergeschoss | 0 | 4.08007e-15
 | Obergeschoss | 0.5 | 0.0995713
 | Obergeschoss | 1.16945e-16 | 0.0400576
 | Obergeschoss | 5.30092e-17 | 0.108338
 | Obergeschoss | 8.50411e-33 | 7.16072e-15
2 x  | Obergeschoss | 7.79634e-17 | 6.70834
 | Obergeschoss | 3.13878e-32 | 0.235079
 | Obergeschoss | 0.00125348 | 16.361
 | Obergeschoss | 5.02204e-31 | 0.437685
 | Obergeschoss | 0 | 0.0547908
 | Obergeschoss | 6.27756e-31 | 0.0857063

# IfcPipeSegment: Kupferrohre in Stangen 5 m, 35 x 1,5 mm (437)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0015 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209007; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.032 m; InnerDiameter: 0.032 m; OuterDiameter: 0.035 m
Name | In | Length (m) | Gradient
 | Obergeschoss | 4.9775 | 7.79634e-17
 | Obergeschoss | 1.13194 | 7.79634e-17
2 x  | Obergeschoss | 0.147771 | 3.13878e-32
2 x  | Obergeschoss | 0.110119 | 7.79634e-17
34 x  | Obergeschoss | 0.104 | 1
 | Obergeschoss | 0.832363 | 0
6 x  | Obergeschoss | 0.092 | 0
2 x  | Obergeschoss | 7.10543e-15 | 6.33945e-17
2 x  | Obergeschoss | 0.0971536 | 3.13878e-32
32 x  | Obergeschoss | 0.118627 | 0.5
2 x  | Obergeschoss | 3.55271e-15 | 3.80876e-33
2 x  | Obergeschoss | 3.55271e-15 | 6.33945e-17
10 x  | Obergeschoss | 5.49316e-07 | 6.33945e-17
2 x  | Obergeschoss | 0.249322 | 0
2 x  | Obergeschoss | 0.166334 | 3.13878e-32
 | Obergeschoss | 1.11648 | 1.55927e-16
9 x  | Obergeschoss | 0.0452645 | 0
 | Obergeschoss | 1.20966 | 0
2 x  | Obergeschoss | 0.0364299 | 7.79634e-17
 | Obergeschoss | 0.462475 | 0
2 x  | Obergeschoss | 0.0298149 | 7.79634e-17
2 x  | Obergeschoss | 0.104649 | 5.45744e-16
 | Obergeschoss | 1.20217 | 0
3 x  | Obergeschoss | 0.092 | 3.53395e-17
4 x  | Untergeschoss | 0.052 | 1
4 x  | Untergeschoss | 0.004 | 3.89817e-17
 | Untergeschoss | 0.226 | 1
4 x  | Untergeschoss | 0.552 | 1
 | Untergeschoss | 0.997095 | 1.02376e-16
2 x  | Untergeschoss | 0.054 | 3.89817e-17
2 x  | Untergeschoss | 0.152 | 1
3 x  | Untergeschoss | 0.171 | 1
 | Untergeschoss | 0.029 | 1
 | Untergeschoss | 1.3406 | 6.33945e-17
 | Untergeschoss | 0.101 | 1
 | Untergeschoss | 0.128 | 6.33945e-17
2 x  | Obergeschoss | 0.0698897 | 3.13878e-32
 | Untergeschoss | 0.190167 | 1.55927e-16
 | Untergeschoss | 0.59919 | 0
 | Untergeschoss | 0.2975 | 1
 | Untergeschoss | 0.0708813 | 0
 | Untergeschoss | 0.479503 | 1.02376e-16
 | Untergeschoss | 0.25739 | 0
 | Untergeschoss | 0.342167 | 4.08041e-31
 | Untergeschoss | 1.854 | 1
 | Untergeschoss | 0.713808 | 0
 | Untergeschoss | 1.424 | 1
 | Untergeschoss | 0.286028 | 0
 | Untergeschoss | 0.128 | 7.79634e-17
 | Untergeschoss | 0.499008 | 0
 | Untergeschoss | 0.285778 | 0
3 x  | Obergeschoss | 7.10543e-15 | 3.80876e-33
 | Untergeschoss | 0.0706313 | 0
 | Erdgeschoss | 0.159045 | 7.79634e-17
 | Erdgeschoss | 1.05625 | 7.79634e-17
 | Erdgeschoss | 0.289976 | 6.33945e-17
 | Erdgeschoss | 0.054 | 1
 | Erdgeschoss | 5.87116 | 0
2 x  | Erdgeschoss | 0.454 | 1
 | Erdgeschoss | 0.092 | 7.0679e-17
2 x  | Erdgeschoss | 0.118627 | 0.5
 | Erdgeschoss | 8.19967 | 7.79634e-17
 | Erdgeschoss | 6.04492 | 1.16945e-16
 | Erdgeschoss | 0.173025 | 3.13878e-32
 | Erdgeschoss | 0.295992 | 0
 | Erdgeschoss | 0.0505707 | 1.94367e-16
 | Erdgeschoss |  | 1
 | Erdgeschoss | 1.1873 | 0
 | Erdgeschoss | 0.39638 | 7.79634e-17
2 x  | Erdgeschoss | 0.354 | 1
 | Erdgeschoss | 0.00228157 | 6.33945e-17
 | Erdgeschoss |  | 7.79634e-17
2 x  | Obergeschoss | 0.173333 | 3.53395e-17
 | Erdgeschoss | 0.41036 | 0
 | Erdgeschoss | 0.115172 | 0
2 x  | Obergeschoss | 0.0636055 | 0
 | Erdgeschoss | 8.45299 | 7.79634e-17
2 x  | Obergeschoss | 0.0837305 | 0
2 x  | Obergeschoss | 0.028 | 1
2 x  | Obergeschoss | 0.252 | 1
2 x  | Obergeschoss |  | 6.33945e-17
2 x  | Erdgeschoss | 4.229 | 1
2 x  | Erdgeschoss | 0.129 | 1
2 x  | Obergeschoss | 0.0512182 | 7.79634e-17
 | Erdgeschoss | 0.055865 | 0
 | Erdgeschoss | 0.157526 | 3.89817e-17
 | Erdgeschoss | 0.217373 | 3.89817e-17
 | Erdgeschoss | 0.234393 | 6.33945e-17
2 x  | Erdgeschoss | 0.126 | 1
 | Erdgeschoss | 0.0561352 | 3.89817e-17
2 x  | Obergeschoss | 0.15972 | 3.53395e-17
 | Erdgeschoss | 0.192526 | 3.89817e-17
 | Erdgeschoss | 8.5021 | 0
 | Erdgeschoss | 8.26426 | 0
2 x  | Obergeschoss | 2.12643 | 1.76697e-17
 | Erdgeschoss | 0.124053 | 6.33945e-17
 | Erdgeschoss | 0.147102 | 0
2 x  | Obergeschoss | 0.0759033 | 1.55927e-16
2 x  | Obergeschoss | 1.15496 | 3.58869e-16
2 x  | Obergeschoss | 0.666732 | 7.79634e-17
4 x  | Obergeschoss | 0.092 | 7.0679e-17
2 x  | Obergeschoss | 3.55271e-15 | 1.14145e-31
2 x  | Obergeschoss | 0.00657124 | 7.79634e-17
 | Obergeschoss | 1.25827 | 0
2 x  | Obergeschoss | 0.0831137 | 7.79634e-17
2 x  | Obergeschoss | 0.127852 | 3.58869e-16
 | Obergeschoss | 0.929716 | 0
 | Obergeschoss | 1.42109e-14 | 5.54477e-32
4 x  | Obergeschoss | 0.153522 | 0
2 x  | Obergeschoss | 0.0280456 | 0
2 x  | Obergeschoss | 0.259338 | 0
 | Obergeschoss | 7.94411e-15 | 3.80876e-33
2 x  | Obergeschoss | 0.0485465 | 7.79634e-17
2 x  | Obergeschoss | 0.0737147 | 0
2 x  | Obergeschoss | 0.0623226 | 7.79634e-17
 | Obergeschoss | 1.09791 | 7.79634e-17
 | Obergeschoss | 0.046408 | 3.13878e-32
 | Obergeschoss | 0.699102 | 7.79634e-17
 | Obergeschoss | 0.0796104 | 7.79634e-17
 | Obergeschoss | 0.144146 | 7.79634e-17
 | Obergeschoss | 0.090165 | 0
 | Obergeschoss | 0.0216962 | 0
 | Obergeschoss | 0.118238 | 7.79634e-17
3 x  | Obergeschoss | 0 | 6.33945e-17
 | Obergeschoss | 0.067217 | 7.79634e-17
 | Obergeschoss | 1.77636e-15 | 1.04365e-33
 | Obergeschoss | 1.0383 | 0
2 x  | Obergeschoss | 0.164945 | 3.53395e-17
 | Obergeschoss | 1.15594 | 7.79634e-17
 | Obergeschoss | 0.092 | 1.41358e-16
2 x  | Obergeschoss | 0.127344 | 3.53395e-17
 | Obergeschoss | 0.0704194 | 3.13878e-32
 | Obergeschoss | 0 | 5.54477e-32
 | Obergeschoss | 0.929716 | 3.58869e-16
 | Obergeschoss | 0.134363 | 3.53395e-17
 | Obergeschoss | 0.19869 | 3.53395e-17
 | Obergeschoss | 1.20933 | 2.3389e-16
 | Obergeschoss | 3.55271e-15 | 5.54477e-32
 | Obergeschoss | 0.0974913 | 2.3389e-16
 | Obergeschoss | 0.0674446 | 7.79634e-17
 | Obergeschoss | 1.20217 | 5.45744e-16
 | Obergeschoss | 3.10188 | 0
 | Obergeschoss | 3.25605 | 0
2 x  | Obergeschoss | 3.25721 | 0
2 x  | Obergeschoss | 5.01577 | 0
 | Obergeschoss | 4.19566 | 1.55927e-16
 | Obergeschoss | 4.50465 | 1.55927e-16
 | Obergeschoss | 0.0858793 | 7.79634e-17
2 x  | Obergeschoss | 0.0300142 | 0
2 x  | Obergeschoss | 5.835 | 1.55927e-16
 | Obergeschoss | 0.115231 | 7.79634e-17
 | Obergeschoss | 0.104 | 1 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 3.65881 | 3.89817e-17
2 x  | Obergeschoss | 6.07503 | 7.79634e-17
 | Obergeschoss | 4.09197 | 1.55927e-16
4 x  | Obergeschoss | 3.976 | 1
2 x  | Obergeschoss | 4.42661 | 0
2 x  | Obergeschoss | 0.123498 | 0
 | Obergeschoss | 4.21879 | 7.79634e-17
2 x  | Obergeschoss | 0.023505 | 7.79634e-17
2 x  | Obergeschoss | 0.286698 | 3.89817e-17
 | Obergeschoss | 7.32422e-07 | 5.24854e-33 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 0.112664 | 7.79634e-17
2 x  | Obergeschoss | 1.79681 | 0
 | Obergeschoss | 2.66385 | 7.79634e-17
 | Obergeschoss | 3.84297 | 7.79634e-17
2 x  | Obergeschoss | 0.217335 | 7.79634e-17
 | Obergeschoss | 2.66454e-15 | 9.7858e-17 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 1.02308 | 3.13878e-32
 | Obergeschoss | 8.36052 | 7.79634e-17
2 x  | Obergeschoss | 0 | 6.94454e-33
 | Obergeschoss | 4.57271 | 7.79634e-17 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x  | Obergeschoss | 0.284296 | 3.89817e-17
2 x  | Obergeschoss | 3.83698 | 3.89817e-17
 | Obergeschoss | 3.16089 | 2.13996e-16
2 x  | Obergeschoss | 0.141582 | 1.55927e-16
2 x  | Obergeschoss | 0.286674 | 7.79634e-17
2 x  | Obergeschoss | 0.0601377 | 1.55927e-16
 | Obergeschoss | 6.77211 | 2.13996e-16
 | Obergeschoss | 0.154282 | 3.13878e-32 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 3.29357 | 0
2 x  | Obergeschoss | 5.15323 | 0
 | Obergeschoss | 0.123851 | 1.55927e-16 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
 | Obergeschoss | 3.12895 | 0
 | Obergeschoss | 3.51879 | 7.79634e-17
 | Obergeschoss | 0.104 | 1 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 6.46452 | 0
 | Obergeschoss | 7.32422e-07 | 5.24854e-33 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 5.14297 | 7.79634e-17
 | Obergeschoss | 2.06385 | 7.79634e-17
 | Obergeschoss | 0.154282 | 3.13878e-32 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 4.87271 | 7.79634e-17 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 3.46089 | 2.13996e-16
 | Obergeschoss | 6.47211 | 0
 | Obergeschoss | 8.88178e-16 | 9.7858e-17 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 8.06052 | 7.79634e-17
 | Obergeschoss | 0.123851 | 1.55927e-16 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
 | Obergeschoss | 5.39197 | 1.55927e-16
 | Obergeschoss | 3.19566 | 1.55927e-16
 | Obergeschoss | 6.39993 | 0
 | Obergeschoss | 4.20465 | 1.55927e-16
 | Obergeschoss | 0.532363 | 0
 | Obergeschoss | 0.162475 | 7.79634e-17
2 x  | Obergeschoss | 0.602075 | 3.13878e-32
 | Obergeschoss | 1.20966 | 3.13878e-32
 | Obergeschoss | 1.11648 | 3.13878e-32
2 x  | Obergeschoss | 0.0827016 | 0
 | Obergeschoss | 4.06312 | 0
 | Obergeschoss | 2.94278 | 0
 | Obergeschoss | 3.34447 | 1.55927e-16
2 x  | Obergeschoss | 3.60677 | 0
 | Obergeschoss | 1.77449 | 7.79634e-17
 | Obergeschoss | 2.12062 | 0
 | Obergeschoss | 0.432768 | 7.79634e-17
 | Obergeschoss | 3.04248 | 0
 | Obergeschoss | 4.20559 | 7.79634e-17
 | Obergeschoss | 4.98841 | 1.55927e-16
 | Obergeschoss | 0.723909 | 7.79634e-17
 | Obergeschoss | 4.18883 | 7.79634e-17
 | Obergeschoss | 4.63511 | 7.79634e-17
2 x  | Obergeschoss | 5.75183 | 7.79634e-17
2 x  | Obergeschoss | 9.69508 | 1.16945e-16
 | Obergeschoss | 0.9496 | 1.94909e-16
 | Obergeschoss | 0.113797 | 0
 | Obergeschoss | 0.115797 | 1.16945e-16
2 x  | Obergeschoss | 5.50077 | 7.79634e-17
 | Obergeschoss | 5.9912 | 1.94909e-16
 | Obergeschoss | 0.102737 | 9.41633e-32
2 x  | Obergeschoss | 5.39443 | 1.94909e-16
2 x  | Obergeschoss | 9.86885 | 1.16945e-16
 | Obergeschoss | 0.092 | 5.30092e-17
 | Obergeschoss | 1.77636e-15 | 2.93584e-32
 | Obergeschoss | 0.154835 | 2.12037e-16
 | Obergeschoss | 1.15082 | 7.79634e-17
 | Obergeschoss | 1.25827 | 7.79634e-17
 | Obergeschoss | 1.77636e-15 | 1.00344e-31
 | Obergeschoss | 0.137455 | 2.12037e-16
 | Obergeschoss | 0.132768 | 0
 | Obergeschoss | 0.0423404 | 0
 | Obergeschoss | 0.0254569 | 1.16945e-16
 | Obergeschoss | 0.0236742 | 1.16945e-16
 | Obergeschoss | 5.6912 | 1.94909e-16
 | Obergeschoss | 1.2496 | 1.94909e-16
 | Obergeschoss | 0.0421231 | 0
 | Obergeschoss | 0.129522 | 7.79634e-17
 | Obergeschoss | 0.092 | 2.65046e-16
 | Obergeschoss | 0.0216962 | 1.55927e-16
 | Obergeschoss | 6.01132 | 7.79634e-17
 | Obergeschoss | 3.32047 | 1.55927e-16
 | Obergeschoss | 7.10543e-15 | 1.02049e-32
 | Obergeschoss | 0.067217 | 5.06762e-15
 | Obergeschoss | 4.93511 | 7.79634e-17
 | Obergeschoss | 4.96441 | 1.55927e-16

# IfcPipeSegment: Kupferrohre in Stangen 5 m, 42 x 1,5 mm (13)
In: Untergeschoss
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0015 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209008; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.04 m; InnerDiameter: 0.039 m; OuterDiameter: 0.042 m
Name | Gradient | Length (m)
 | 0 | 0.160483
 | 1 | 2.012
 | 0 | 0.0202416
 | 1 | 2.484
 | 0 | 0.113921
 | 0 | 4.09618
 | 3.13878e-32 | 3.97371
 | 7.79634e-17 | 2.06174
 | 3.89817e-17 | 6.60594
 | 0
 | 1.47824e-30 | 7.2477
 | 7.79634e-17 | 2.21095
 | 1.56939e-32 | 0.232298

# IfcSpaceHeater: Deckenstrahlplatte 900 mm BL 1000 RA 100 (34)
In: Obergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-180717-106; Manufacturer: DDS
Type - Pset_SpaceHeaterTypeCommon - TemperatureClassification: LOWTEMPERATURE; HeatTransferMedium: WATER; OutputCapacity: 0 W
HK_Test - Lxbxh: 1000 mm x 900 mm x 50 mm
Name
30 x -0
2 x -0 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
2 x -0 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro

# IfcSpaceHeater: VN-PLAN Multifunktionsheizkörper 22 900/2400 (2)
In: Erdgeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: H1-00045403836763022; Manufacturer: Cosmo
Type - Pset_SpaceHeaterTypeCommon - TemperatureClassification: LOWTEMPERATURE; HeatTransferMedium: WATER; OutputCapacity: 5396 W
HK_Test - Lxbxh: 2400 mm x 107 mm x 900 mm

# IfcValve: Hydraulische Schaltung
In: Untergeschoss
Type - PredefinedType: MIXING
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HU001; Manufacturer: DDScad

# IfcValve: Muffenschieber Rot-Gelb PN 20 1 1/4", mit konischer Dichtung (44)
In: Obergeschoss
Type - PredefinedType: ISOLATING
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA322/07; Manufacturer: DDScad
Name
30 x -16
8 x -17
4 x -19
-18 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
-18 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro

# IfcValve: Muffenschieber Rot-Gelb PN 20 1", mit konischer Dichtung (38)
In: Obergeschoss
Type - PredefinedType: ISOLATING
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA322/06; Manufacturer: DDScad
Name
18 x -16
16 x -18
4 x -17

# IfcValve: Muffenschieber Rot-Gelb PN 20 3/4", mit konischer Dichtung (32)
In: Obergeschoss
Type - PredefinedType: ISOLATING
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TA322/05; Manufacturer: DDScad
Name
26 x -18
3 x -18 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
3 x -18 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
