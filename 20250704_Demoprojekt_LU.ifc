Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option: [Keine IfcSpaces: On], Option: [Keine Kabel: On], Option [Gebäude: Off], Option [Elektrotechnik: Off], Option [Heizung: Off], Option [Sanitär: Off], Option [Brandschutz: Off], Option [Kälte: Off], Option [Klima/Lüftung: On], Option [Provision for Void: Off]
File name: 20250704_Demoprojekt_LU.ifc
Time: 2025-07-07T17:30:17
Author: onedr
Organization: 123
Written by: DDS_IFC v3.0
Made in: DDScad MEP Version 20 x64 build 20/11-2024
Authorization: DDS

# IfcProject, Archicad Demoprojekt Bürogebäude
Description: Demodatei eines Bürogebäudes mit Verkaufsfläche

# IfcSite, Grundstück
RefLatitude: 51, 47, 22, 999999; RefLongitude: 7, 37, 12, 999999; RefElevation: 62 m
Pset_LandRegistration - IsPermanentID: no

# IfcBuilding, DDScad-Demoprojekt-Buero-18
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (6)
In: DDScad-Demoprojekt-Buero-18
Name | Description | Elevation (m)
Untergeschoss | Untergeschoss | -3.5
Obergeschoss | Obergeschoss | 4.4
Dachaufsicht | Dachaufsicht | 13.2
Obergeschoss | Obergeschoss | 8.8
Erdgeschoss | Erdgeschoss | 0
Fundament | Fundament | -5.3

# IfcAirTerminal: Tellerventil 100 ø130 Abluft (15)
Type - PredefinedType: DIFFUSER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GV-140508-441; Manufacturer: DDScad
Name | In
8 x  | Obergeschoss
2 x -1 | Obergeschoss
4 x  | Erdgeschoss
-1 | Erdgeschoss

# IfcAirTerminal: Tellerventil 100 ø130 Zuluft (3)
Type - PredefinedType: DIFFUSER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: GV-140508-311; Manufacturer: DDScad
Name | In
2 x -0 | Obergeschoss
-0 | Erdgeschoss

# IfcDistributionPort (331)
FlowDirection: SOURCEANDSINK; PredefinedType: DUCT
Name | NominalWidth (m)
242 x  | 0.15
69 x  | 0.1
20 x  | 0.25

# IfcDuctFitting: Abzweig Wickelfalzrohr 90° d 150/100/150 (15)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: T83015001000150; Manufacturer: DDScad
Name | In
5 x  | Erdgeschoss
10 x  | Obergeschoss

# IfcDuctFitting: Abzweig Wickelfalzrohr 90° d 150/150/150 (6)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: T83015001500150; Manufacturer: DDScad
Name | In
4 x  | Obergeschoss
2 x  | Erdgeschoss

# IfcDuctFitting: Deckel rund DN 150 (3)
Type - PredefinedType: EXIT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LIFr150; Manufacturer: DDScad
Name | In
2 x  | Obergeschoss
 | Erdgeschoss

# IfcDuctFitting: Wickelfalzrohr Bogen 45° d 100 (3)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300100045; Manufacturer: DDScad
Name | In
2 x -17 | Obergeschoss
-17 | Erdgeschoss

# IfcDuctFitting: Wickelfalzrohr Bogen 90° d 100 (3)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300100090; Manufacturer: DDScad
Name | In
-17 | Erdgeschoss
2 x -17 | Obergeschoss

# IfcDuctFitting: Wickelfalzrohr Bogen 90° d 150 (24)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300150090; Manufacturer: DDScad
Name | In
6 x  | Obergeschoss
6 x -17 | Obergeschoss
6 x -17 | Untergeschoss
3 x  | Erdgeschoss
3 x -17 | Erdgeschoss

# IfcDuctFitting: Wickelfalzrohr Bogen 90° d 250 (4)
In: Untergeschoss
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE8300250090; Manufacturer: DDScad

# IfcDuctSegment: Flexibles Rohr DIN 24146 d 100 (12)
Type - PredefinedType: FLEXIBLESEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8305100; Manufacturer: DDScad
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 0.1 m; Shape: ROUND
Name | In | Length (m)
2 x  | Obergeschoss | 1.84705
2 x  | Obergeschoss | 1.60504
2 x  | Obergeschoss | 1.16501
2 x  | Obergeschoss | 1.59998
 | Erdgeschoss | 1.60504
 | Erdgeschoss | 1.59998
 | Erdgeschoss | 1.16501
 | Erdgeschoss | 1.84705

# IfcDuctSegment: Wickelfalzrohr DIN 24145 d 100 (9)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310100; Manufacturer: DDScad
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 0.1 m; Shape: ROUND
Name | In | Length (m)
2 x  | Obergeschoss | 0.0961131
2 x  | Obergeschoss | 0.504903
 | Erdgeschoss | 0.667896
 | Erdgeschoss | 0.504903
 | Erdgeschoss | 0.0961131
2 x  | Obergeschoss | 0.667896

# IfcDuctSegment: Wickelfalzrohr DIN 24145 d 150 (67)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310150; Manufacturer: DDScad
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 0.15 m; Shape: ROUND
Name | In | Length (m)
4 x  | Obergeschoss | 4.085
2 x  | Obergeschoss | 0.135
2 x  | Obergeschoss | 2.83417
2 x  | Obergeschoss | 0.238959
2 x  | Obergeschoss | 1.23056
2 x  | Obergeschoss | 0.596818
2 x  | Untergeschoss | 0.3
 | Erdgeschoss | 0.774368
2 x  | Obergeschoss | 1.61216
2 x  | Obergeschoss | 1.23225
2 x  | Obergeschoss | 0.774368
2 x  | Obergeschoss | 0.450822
2 x  | Obergeschoss | 0.941363
 | Untergeschoss | 1.14516
2 x  | Erdgeschoss | 0.085
 | Untergeschoss | 0.484722
2 x  | Obergeschoss | 0.8
2 x  | Obergeschoss | 0.561828
2 x  | Obergeschoss | 3.05623
 | Erdgeschoss | 2.83417
 | Erdgeschoss | 0.204748
 | Erdgeschoss | 1.23225
2 x  | Obergeschoss | 2.19365
 | Erdgeschoss | 0.596818
2 x  | Obergeschoss | 0.204748
2 x  | Obergeschoss | 0.212687
 | Erdgeschoss | 2.19365
 | Erdgeschoss | 3.05623
2 x  | Obergeschoss | 0.085
 | Erdgeschoss | 1.61216
 | Erdgeschoss | 0.8
2 x  | Erdgeschoss | 4.085
 | Erdgeschoss | 0.450822
 | Erdgeschoss | 0.212687
 | Erdgeschoss | 0.238959
 | Erdgeschoss | 0.941363
 | Erdgeschoss | 1.23056
 | Untergeschoss | 1.46916
 | Erdgeschoss | 0.561828
2 x  | Untergeschoss | 0.8
 | Untergeschoss | 0.793722
2 x  | Dachaufsicht | 1.25

# IfcDuctSegment: Wickelfalzrohr DIN 24145 d 250 (6)
In: Untergeschoss
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS8310250; Manufacturer: DDScad
Type - Pset_DuctSegmentTypeCommon - NominalDiameterOrWidth: 0.25 m; Shape: ROUND
Name | Length (m)
 | 0.131
 | 9.4622
 | 9.8522
2 x  | 0.95
 | 0.298095

# IfcDuctSilencer: Schalldämpfer rund 125 mm L = 900 mm (3)
Type - PredefinedType: ROUND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SI-200227-002; Manufacturer: DDScad
Type - Pset_DuctSilencerTypeCommon - Length: 0.9 m; HasExteriorInsulation: no
Name | In
2 x  | Obergeschoss
 | Erdgeschoss

# IfcDuctSilencer: Schalldämpfer rund 160 mm L = 900 mm (3)
Type - PredefinedType: ROUND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SI-200227-003; Manufacturer: DDScad
Type - Pset_DuctSilencerTypeCommon - Length: 0.9 m; HasExteriorInsulation: no
Name | In
2 x  | Obergeschoss
 | Erdgeschoss

# IfcUnitaryEquipment: Lüftungsgerät mit Wärmerückgewinnung
In: Untergeschoss
Type - PredefinedType: AIRHANDLER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: AH-20111213-093; ModelReference: 7; Manufacturer: DDScad
