Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option: [Keine IfcSpaces: On], Option: [Keine Kabel: On], Option [Gebäude: Off], Option [Elektrotechnik: Off], Option [Heizung: Off], Option [Sanitär: On], Option [Brandschutz: Off], Option [Kälte: Off], Option [Klima/Lüftung: Off], Option [Provision for Void: Off]
File name: 20250704_Demoprojekt_SA.ifc
Time: 2025-07-07T17:30:42
Author: onedr
Organization: 123
Written by: DDS_IFC v3.0
Made in: DDScad MEP Version 20 x64 build 20/11-2024
Authorization: DDS

# IfcProject, Archicad Demoprojekt Bürogebäude
Description: Demodatei eines Bürogebäudes mit Verkaufsfläche

# IfcSite, Grundstück
RefLatitude: 51, 47, 22, 999999; RefLongitude: 7, 37, 12, 999999; RefElevation: 62 m
Pset_LandRegistration - IsPermanentID: no

# IfcBuilding, DDScad-Demoprojekt-Buero-18
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (6)
In: DDScad-Demoprojekt-Buero-18
Name | Description | Elevation (m)
Obergeschoss | Obergeschoss | 8.8
Dachaufsicht | Dachaufsicht | 13.2
Untergeschoss | Untergeschoss | -3.5
Erdgeschoss | Erdgeschoss | 0
Fundament | Fundament | -5.3
Obergeschoss | Obergeschoss | 4.4

# IfcDistributionPort (2385)
FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name | NominalDiameter (m)
340 x  | 0.1
578 x  | 0.025
537 x  | 0.015
270 x  | 0.05
70 x  | 0.07
590 x  | 0.012

# IfcPipeFitting: Cu Abzweig 90° 15/15/15 (8)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-302; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
-06 | Erdgeschoss
2 x -15 | Erdgeschoss
-06 | Obergeschoss
4 x -15 | Obergeschoss

# IfcPipeFitting: Cu Abzweig 90° 18/15/18 (3)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-304; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
-16 | Erdgeschoss
2 x -16 | Obergeschoss

# IfcPipeFitting: Cu Abzweig 90° 18/18/18 (5)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-305; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
 | Erdgeschoss
-06 | Erdgeschoss
2 x  | Obergeschoss
-06 | Obergeschoss

# IfcPipeFitting: Cu Abzweig 90° 28/18/28 (10)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-309; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -17 | Obergeschoss
2 x  | Obergeschoss
 | Erdgeschoss
-17 | Erdgeschoss
2 x -04 | Obergeschoss
-07 | Obergeschoss
-06 | Obergeschoss

# IfcPipeFitting: Cu Abzweig 90° 28/28/28 (5)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-130308-311; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x  | Obergeschoss
-06 | Obergeschoss
 | Erdgeschoss
-06 | Erdgeschoss

# IfcPipeFitting: Cu Doppelwandscheibe 15/1/2"/15 (3)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-160831-001#002; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
-19 | Erdgeschoss
2 x -19 | Obergeschoss

# IfcPipeFitting: Cu Doppelwandscheibe 15/1/2"/15 (3)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-160831-001#003; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
-1 | Erdgeschoss
2 x -1 | Obergeschoss

# IfcPipeFitting: Cu Doppelwandscheibe 18/1/2"/18 (12)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-160831-005#002; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -0 | Obergeschoss
2 x  | Obergeschoss
-0 | Erdgeschoss
-18 | Erdgeschoss
 | Erdgeschoss
-17 | Erdgeschoss
2 x -17 | Obergeschoss
2 x -18 | Obergeschoss

# IfcPipeFitting: Cu Doppelwandscheibe 28/1/2"/28 (4)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-160831-012#002; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
-19 | Erdgeschoss
-18 | Erdgeschoss
-18 | Obergeschoss
-19 | Obergeschoss

# IfcPipeFitting: Cu Doppelwandscheibe 28/1/2"/28 (10)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-160831-012#003; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x  | Erdgeschoss
3 x  | Obergeschoss
-0 | Erdgeschoss
2 x -0 | Obergeschoss
-1 | Obergeschoss
-1 | Erdgeschoss

# IfcPipeFitting: Cu Fitting Bogen 45° 15 x 1 (12)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000015045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.018 m
Name | In
4 x -17 | Erdgeschoss
8 x -17 | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen 45° 18 x 1 (12)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000018045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.0225 m
Name | In
8 x -03 | Obergeschoss
4 x -03 | Erdgeschoss

# IfcPipeFitting: Cu Fitting Bogen 45° 28 x 1,5 (12)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000028045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.0375 m
Name | In
8 x -11 | Obergeschoss
4 x -11 | Erdgeschoss

# IfcPipeFitting: Cu Fitting Bogen 90° 15 x 1 (79)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000015090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.018 m
Name | In
6 x -12 | Obergeschoss
8 x -17 | Obergeschoss
15 x -05 | Obergeschoss
 | Erdgeschoss
4 x -0 | Erdgeschoss
3 x -07 | Erdgeschoss
7 x -05 | Erdgeschoss
6 x -07 | Obergeschoss
4 x -17 | Erdgeschoss
3 x -12 | Erdgeschoss
4 x -08 | Erdgeschoss
2 x  | Obergeschoss
8 x -08 | Obergeschoss
8 x -0 | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen 90° 18 x 1 (79)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000018090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.0225 m
Name | In
2 x -194 | Obergeschoss
2 x -193 | Obergeschoss
7 x -11 | Erdgeschoss
14 x -11 | Obergeschoss
8 x -09 | Obergeschoss
4 x -09 | Erdgeschoss
8 x -07 | Obergeschoss
3 x  | Erdgeschoss
4 x -07 | Erdgeschoss
4 x -06 | Erdgeschoss
8 x -06 | Obergeschoss
7 x  | Obergeschoss
4 x -17 | Obergeschoss
2 x -17 | Erdgeschoss
2 x -192 | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen 90° 28 x 1,5 (95)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE3000028090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.0375 m
Name | In
9 x  | Obergeschoss
4 x  | Erdgeschoss
4 x -14 | Erdgeschoss
4 x -13 | Erdgeschoss
7 x -17 | Erdgeschoss
4 x -1 | Erdgeschoss
4 x -19 | Erdgeschoss
8 x -1 | Obergeschoss
8 x -19 | Obergeschoss
10 x -17 | Obergeschoss
5 x -16 | Obergeschoss
4 x -15 | Obergeschoss
3 x -16 | Erdgeschoss
3 x -195 | Obergeschoss
4 x -15 | Erdgeschoss
3 x -12 | Obergeschoss
3 x -12 | Erdgeschoss
4 x -13 | Obergeschoss
4 x -14 | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen frei 18 x 1 (3)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE30000180xx; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.022772 rad; BendRadius: 0.0225 m
Name | In
 | Erdgeschoss
2 x  | Obergeschoss

# IfcPipeFitting: Cu Fitting Bogen frei 28 x 1,5 (2)
In: Obergeschoss
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE30000280xx; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.392699 rad; BendRadius: 0.0375 m

# IfcPipeFitting: Cu Fitting Reduzierung DN 15/12 (9)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000018015; Manufacturer: DDScad
Name | In
-0 | Erdgeschoss
 | Erdgeschoss
-18 | Erdgeschoss
2 x -0 | Obergeschoss
2 x  | Obergeschoss
2 x -18 | Obergeschoss

# IfcPipeFitting: Cu Fitting Reduzierung DN 25/15 (3)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH3000028018; Manufacturer: DDScad
Name | In
2 x -1 | Obergeschoss
-1 | Erdgeschoss

# IfcPipeFitting: HT Abzweig 45° DN 100x100 (12)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-040; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -07 | Obergeschoss
4 x -11 | Obergeschoss
2 x -13 | Obergeschoss
-13 | Erdgeschoss
2 x -11 | Erdgeschoss
-07 | Erdgeschoss

# IfcPipeFitting: HT Abzweig 45° DN 50x50 (3)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-010; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -12 | Obergeschoss
-12 | Erdgeschoss

# IfcPipeFitting: HT Abzweig 45° DN 70x50 (6)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-016; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
4 x -13 | Obergeschoss
2 x -13 | Erdgeschoss

# IfcPipeFitting: HT Abzweig 87,5° DN 100x100 (9)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-042; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -10 | Obergeschoss
2 x -11 | Obergeschoss
2 x -14 | Obergeschoss
-14 | Erdgeschoss
-11 | Erdgeschoss
-10 | Erdgeschoss

# IfcPipeFitting: HT Abzweig 87,5° DN 70x50 (3)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-018; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -12 | Obergeschoss
-12 | Erdgeschoss

# IfcPipeFitting: HT Abzweig 87,5° DN 70x70 (3)
Type - PredefinedType: JUNCTION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TP-121203-021; Manufacturer: DDScad
Type - Pset_PipeFittingTypeJunction - JunctionType: TEE
Name | In
2 x -13 | Obergeschoss
-13 | Erdgeschoss

# IfcPipeFitting: HT Bogen 45° DN/OD 100/110 (24)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100100045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.06 m
Name | In
2 x -196 | Erdgeschoss
2 x -01 | Obergeschoss
8 x -199 | Obergeschoss
4 x -196 | Obergeschoss
2 x -195 | Obergeschoss
-01 | Erdgeschoss
4 x -199 | Erdgeschoss
-195 | Erdgeschoss

# IfcPipeFitting: HT Bogen 45° DN/OD 50/50 (33)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050045; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 0.785398 rad; BendRadius: 0.03 m
Name | In
8 x -01 | Obergeschoss
6 x -00 | Obergeschoss
8 x -02 | Obergeschoss
4 x -02 | Erdgeschoss
4 x -01 | Erdgeschoss
3 x -00 | Erdgeschoss

# IfcPipeFitting: HT Bogen 87° DN/OD 100/110 (18)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100100090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.06 m
Name | In
-196 | Erdgeschoss
3 x -199 | Erdgeschoss
2 x -01 | Obergeschoss
6 x -199 | Obergeschoss
2 x -196 | Obergeschoss
2 x -195 | Obergeschoss
-01 | Erdgeschoss
-195 | Erdgeschoss

# IfcPipeFitting: HT Bogen 87° DN/OD 50/50 (18)
Type - PredefinedType: BEND; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BE5100050090; Manufacturer: DDScad
Type - Pset_PipeFittingTypeBend - BendAngle: 1.5708 rad; BendRadius: 0.03 m
Name | In
2 x -02 | Obergeschoss
6 x -01 | Obergeschoss
4 x -00 | Obergeschoss
-02 | Erdgeschoss
3 x -01 | Erdgeschoss
2 x -00 | Erdgeschoss

# IfcPipeFitting: HT Reduzierung DN 100/50 (3)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100100050; Manufacturer: DDScad
Name | In
2 x -18 | Obergeschoss
-18 | Erdgeschoss

# IfcPipeFitting: HT Reduzierung DN 70/50 (3)
Type - PredefinedType: TRANSITION; Material: layer 0 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: CH5100075050; Manufacturer: DDScad
Name | In
2 x -18 | Obergeschoss
-18 | Erdgeschoss

# IfcPipeSegment: HT-Abflussrohr DN/OD 100/110 (95)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0027 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0619; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.1 m; InnerDiameter: 0.1046 m; OuterDiameter: 0.11 m
Name | In | Length (m) | Gradient
 | Erdgeschoss | 0.236567 | 0.00636599
2 x  | Obergeschoss | 0.0686888 | 1
2 x  | Obergeschoss | 0.067797 | 1
 | Obergeschoss | 3.96301 | 1
5 x  | Obergeschoss | 0.0906045 | 0.00636599
2 x  | Obergeschoss | 0.411501 | 0.0063663
2 x  | Obergeschoss | 0.0031886 | 1
4 x  | Obergeschoss |  | 0.506366
2 x  | Obergeschoss | 0.0849492 | 0.00636599
 | Obergeschoss | 0.0252207 | 1
2 x  | Obergeschoss | 0.0447817 | 0.506366
 | Obergeschoss | 0.226611 | 0.00636599
 | Obergeschoss | 0.0157217 | 1
2 x  | Obergeschoss | 0.790056 | 0.0063663
2 x  | Obergeschoss | 0.877054 | 0.00636599
2 x  | Obergeschoss | 0.0377336 | 0.506366
2 x  | Obergeschoss | 0.0377337 | 0.506366
2 x  | Obergeschoss | 0.151 | 1
 | Obergeschoss | 0.12026 | 1
2 x  | Obergeschoss | 0.0447818 | 0.506366
2 x  | Obergeschoss | 0.0156008 | 0.00636599
2 x  | Obergeschoss | 0.131029 | 1
2 x  | Obergeschoss | 0.722967 | 0.00636599
2 x  | Obergeschoss | 0.100076 | 0.0063663
 | Obergeschoss | 0.12162 | 1
3 x  | Obergeschoss | 0 | 1
 | Obergeschoss | 0.0162008 | 0.00636599
 | Obergeschoss | 0.0119335 | 0.00636599
2 x  | Obergeschoss | 0.193995 | 1
 | Obergeschoss | 0.0252147 | 1
 | Obergeschoss | 4.03301 | 1
 | Obergeschoss | 4.066 | 1
2 x  | Obergeschoss | 0.137703 | 0.0063663
 | Erdgeschoss | 0.793871 | 0.0063663
 | Erdgeschoss | 0.137703 | 0.0063663
 | Erdgeschoss | 4.066 | 1
 | Erdgeschoss | 0.151 | 1
 | Obergeschoss | 1.38778e-17 | 1
 | Erdgeschoss | 0.0686888 | 1
 | Erdgeschoss | 0.067797 | 1
 | Erdgeschoss | 0.0031886 | 1
 | Erdgeschoss | 3.96301 | 1
2 x  | Erdgeschoss |  | 0.506366
 | Erdgeschoss | 0.0849492 | 0.00636599
 | Obergeschoss | 4.136 | 1
2 x  | Obergeschoss | 0.793871 | 0.0063663
 | Erdgeschoss | 0.0447818 | 0.506366
 | Erdgeschoss | 0.241212 | 0.00636599
 | Erdgeschoss | 0.0377337 | 0.506366
 | Erdgeschoss | 0.877054 | 0.00636599
 | Erdgeschoss | 0.192489 | 1
 | Erdgeschoss | 0.100076 | 0.0063663
 | Erdgeschoss | 0.0237147 | 1
 | Erdgeschoss | 0.0377336 | 0.506366
 | Erdgeschoss | 0.240612 | 0.00636599
 | Erdgeschoss | 0.12012 | 1
 | Erdgeschoss | 0.722967 | 0.00636599
 | Erdgeschoss | 0.790056 | 0.0063663
 | Erdgeschoss | 0.12957 | 1
 | Dachaufsicht | 0.5 | 1
 | Erdgeschoss | 0.0142584 | 1
 | Erdgeschoss | 0.411501 | 0.0063663
 | Dachaufsicht | 0.75 | 1
 | Erdgeschoss | 0.161941 | 0.00636599
 | Erdgeschoss | 0.0447817 | 0.506366
 | Erdgeschoss | 0.166208 | 0.00636599

# IfcPipeSegment: HT-Abflussrohr DN/OD 50 /50 (72)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0018 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0319; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.05 m; InnerDiameter: 0.0464 m; OuterDiameter: 0.05 m
Name | In | Gradient | Length (m)
2 x  | Obergeschoss | 0.00636599 | 0.0362452
2 x  | Obergeschoss | 0.506366 | 0.0482714
2 x  | Obergeschoss | 0.00636599 | 0.380874
2 x  | Obergeschoss | 1 | 0.27141
2 x  | Obergeschoss | 0.00636599 | 0.0735004
4 x  | Obergeschoss | 0.506366
2 x  | Obergeschoss | 0.00636599 | 0.640609
2 x  | Obergeschoss | 0.506366 | 0.130878
4 x  | Obergeschoss | 0.00636599 | 0.0978305
4 x  | Obergeschoss | 0.00636599 | 0.0733583
2 x  | Obergeschoss | 0.0063663 | 0.0826182
2 x  | Obergeschoss | 1 | 0.280305
2 x  | Obergeschoss | 1 | 0.289202
2 x  | Obergeschoss | 1 | 0.287077
2 x  | Obergeschoss | 0.506366 | 0.0813078
2 x  | Obergeschoss | 1 | 0.294661
2 x  | Obergeschoss | 0.506363 | 0.130871
2 x  | Obergeschoss | 1 | 0.400056
2 x  | Obergeschoss | 0.0063663 | 1.51789
2 x  | Obergeschoss | 0.00636494 | 1.76432
2 x  | Obergeschoss | 0.00900084 | 0.05
 | Erdgeschoss | 0.00900084 | 0.05
 | Erdgeschoss | 0.00636494 | 1.76432
 | Erdgeschoss | 0.0063663 | 1.51789
 | Erdgeschoss | 0.00636599 | 0.380874
 | Erdgeschoss | 0.506363 | 0.130871
 | Erdgeschoss | 0.506366 | 0.0482714
 | Erdgeschoss | 1 | 0.400056
 | Erdgeschoss | 0.00636599 | 0.0362452
2 x  | Erdgeschoss | 0.506366
 | Erdgeschoss | 1 | 0.27141
 | Erdgeschoss | 0.00636599 | 0.0735004
2 x  | Erdgeschoss | 0.00636599 | 0.0733583
 | Erdgeschoss | 1 | 0.289202
2 x  | Erdgeschoss | 0.00636599 | 0.0978305
 | Erdgeschoss | 0.506366 | 0.0813078
 | Erdgeschoss | 1 | 0.280305
 | Erdgeschoss | 0.506366 | 0.130878
 | Erdgeschoss | 0.00636599 | 0.640609
 | Erdgeschoss | 1 | 0.294661
 | Erdgeschoss | 1 | 0.287077
 | Erdgeschoss | 0.0063663 | 0.0826182

# IfcPipeSegment: HT-Abflussrohr DN/OD 70 /75 (20)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0018 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: HT12/0419; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.07 m; InnerDiameter: 0.0712 m; OuterDiameter: 0.0748 m
Name | In | Gradient | Length (m)
2 x  | Obergeschoss | 0.0063663 | 0.517964
2 x  | Obergeschoss | 1 | 0.175
2 x  | Obergeschoss | 0.00636599 | 0.761705
2 x  | Obergeschoss | 0.00636599 | 0.387126
2 x  | Obergeschoss | 1 | 0.026
 | Obergeschoss | 1 | 3.949
 | Obergeschoss | 1 | 1.38778e-17
 | Erdgeschoss | 1 | 0.026
 | Erdgeschoss | 1 | 0.175
 | Erdgeschoss | 1 | 3.949
 | Erdgeschoss | 0.0063663 | 0.517964
 | Obergeschoss | 1 | 4.019
 | Erdgeschoss | 0.00636599 | 0.387126
 | Erdgeschoss | 0.00636599 | 0.761705
 | Dachaufsicht | 1 | 0.75

# IfcPipeSegment: Kupferrohre in Stangen 5 m, 15 x 1 mm (164)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.001 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209003; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.012 m; InnerDiameter: 0.013 m; OuterDiameter: 0.015 m
Name | In | Length (m) | Gradient
 | Obergeschoss | 0.388 | 1
2 x  | Obergeschoss | 0.0508895 | 3.13878e-32
12 x  | Obergeschoss | 0.016 | 2.44128e-17
2 x  | Obergeschoss | 0 | 7.0679e-17
2 x  | Obergeschoss | 3.034 | 1
4 x  | Erdgeschoss | 0.449 | 1
 | Erdgeschoss | 0.34609 | 7.18322e-15
 | Erdgeschoss | 3.48056 | 1.02376e-16
 | Erdgeschoss | 3.30253 | 7.79634e-17
 | Erdgeschoss | 0 | 6.33945e-17
 | Erdgeschoss | 3.988 | 1
 | Erdgeschoss | 3.87226 | 7.79634e-17
2 x  | Obergeschoss | 0.0792465 | 7.79634e-17
7 x  | Erdgeschoss | 0.016 | 2.44128e-17
 | Erdgeschoss | 0.274 | 1
 | Erdgeschoss | 0.0045 | 0
 | Erdgeschoss | 0.0792465 | 7.79634e-17
 | Erdgeschoss | 0.119082 | 7.79634e-17
 | Erdgeschoss | 0.135197 | 6.33945e-17
 | Erdgeschoss | 0.139489 | 7.79634e-17
 | Erdgeschoss | 0.63518 | 7.79634e-17
2 x  | Obergeschoss | 0.0045 | 0
 | Obergeschoss | 3.48056 | 1.02376e-16
2 x  | Erdgeschoss | 0.484 | 1
 | Erdgeschoss | 0.939624 | 1.67397e-16
2 x  | Obergeschoss | 0.119082 | 7.79634e-17
 | Erdgeschoss | 2.0134 | 7.79634e-17
2 x  | Obergeschoss | 0.135197 | 6.33945e-17
 | Erdgeschoss | 0.0574675 | 7.79634e-17
 | Erdgeschoss | 0.643837 | 3.13878e-32
4 x  | Obergeschoss | 0.484 | 1
2 x  | Obergeschoss | 0.643837 | 3.13878e-32
 | Erdgeschoss | 3.14317 | 7.79634e-17
2 x  | Obergeschoss | 3.30253 | 7.79634e-17
2 x  | Erdgeschoss | 2.514 | 1
 | Erdgeschoss | 0.131009 | 6.33945e-17
 | Erdgeschoss | 1.59561 | 0
 | Erdgeschoss | 0.0508895 | 3.13878e-32
 | Erdgeschoss | 0.534918 | 7.79634e-17
 | Erdgeschoss | 0.654633 | 7.79634e-17
2 x  | Obergeschoss | 0.139489 | 7.79634e-17
 | Erdgeschoss | 0.0426975 | 0
 | Obergeschoss | 3.55271e-15 | 6.33945e-17
2 x  | Obergeschoss | 3.87226 | 7.79634e-17
 | Erdgeschoss | 0.743857 | 7.79634e-17
2 x  | Obergeschoss | 0.274 | 1
4 x  | Erdgeschoss | 0.016 | 3.89817e-17
 | Erdgeschoss | 0.025 | 2.9687e-32
 | Obergeschoss | 3.988 | 1
 | Erdgeschoss | 0.0562465 | 7.79634e-17
 | Erdgeschoss |  | 3.89817e-17
 | Erdgeschoss | 0.0562465 | 3.89817e-17
2 x  | Obergeschoss | 3.14317 | 7.79634e-17
 | Erdgeschoss | 0.193027 | 7.79634e-17
4 x  | Obergeschoss | 2.514 | 1
2 x  | Obergeschoss | 0.0562465 | 7.79634e-17
2 x  | Obergeschoss | 0.743857 | 7.79634e-17
2 x  | Obergeschoss | 1.59561 | 0
2 x  | Obergeschoss | 0.193027 | 7.79634e-17
2 x  | Obergeschoss | 0.34609 | 7.18322e-15
8 x  | Obergeschoss | 0.449 | 1
2 x  | Obergeschoss | 0.939624 | 1.67397e-16
2 x  | Obergeschoss | 0.131009 | 6.33945e-17
2 x  | Obergeschoss | 0.63518 | 7.79634e-17
4 x  | Obergeschoss | 0.0678198 | 0.5
2 x  | Obergeschoss | 0.0562465 | 3.89817e-17
2 x  | Obergeschoss | 0.311062 | 7.0679e-17
2 x  | Obergeschoss | 0.534918 | 7.79634e-17
2 x  | Obergeschoss |  | 3.89817e-17
 | Erdgeschoss | 0.0144388 | 7.79634e-17
2 x  | Obergeschoss | 0.075 | 1.06018e-16
2 x  | Erdgeschoss | 0.0678198 | 0.5
2 x  | Obergeschoss | 0.025 | 2.9687e-32
4 x  | Obergeschoss | 0.016 | 3.89817e-17
2 x  | Obergeschoss | 0.0426975 | 0
2 x  | Obergeschoss | 0.0144388 | 7.79634e-17
 | Erdgeschoss | 0.075 | 1.06018e-16
 | Erdgeschoss | 0.311062 | 7.0679e-17
 | Erdgeschoss | 3.034 | 1
 | Erdgeschoss | 3.55271e-15 | 7.0679e-17
2 x  | Obergeschoss | 2.0134 | 7.79634e-17
2 x  | Obergeschoss | 0.654633 | 7.79634e-17
2 x  | Obergeschoss | 0.0574675 | 7.79634e-17
 | Obergeschoss | 0 | 6.33945e-17
 | Obergeschoss | 3.47456 | 1.02376e-16
 | Obergeschoss | 3.982 | 1
 | Erdgeschoss | 0.388 | 1

# IfcPipeSegment: Kupferrohre in Stangen 5 m, 18 x 1 mm (141)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.001 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209004; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.015 m; InnerDiameter: 0.016 m; OuterDiameter: 0.018 m
Name | In | Gradient | Length (m)
 | Erdgeschoss | 1 | 0.386
 | Obergeschoss | 6.32418e-17 | 0.0225
 | Obergeschoss | 1.52795e-19 | 0.0225
4 x  | Obergeschoss | 1 | 0.1425
 | Obergeschoss | 1 | 0.386
 | Obergeschoss | 6.0944e-17 | 0.0304479
 | Obergeschoss | 7.79634e-17 | 0.0225
 | Obergeschoss | 1.0358e-30 | 0.0225
 | Obergeschoss | 6.0944e-17 | 0.034715
2 x  | Obergeschoss | 1.23688e-16 | 1.50351
2 x  | Erdgeschoss | 2.24972e-32 | 0.0915257
2 x  | Obergeschoss | 7.79634e-17 | 0.62
4 x  | Obergeschoss | 7.79634e-17 | 0.0915257
 | Obergeschoss | 7.79634e-17 | 0.975595
2 x  | Erdgeschoss | 7.79634e-17 | 0.0915257
8 x  | Obergeschoss | 1 | 0.3945
4 x  | Obergeschoss | 2.24972e-32 | 0.0915257
2 x  | Obergeschoss | 6.33945e-17 | 0.321037
2 x  | Obergeschoss | 1 | 2.555
 | Erdgeschoss | 7.79634e-17 | 1.03506
 | Erdgeschoss | 1 | 2.555
4 x  | Obergeschoss | 7.79634e-17 | 0.0670547
 | Erdgeschoss | 6.33945e-17 | 0.321037
2 x  | Obergeschoss | 7.79634e-17 | 0.768499
 | Erdgeschoss | 7.79634e-17 | 0.204797
4 x  | Erdgeschoss | 1 | 0.3945
2 x  | Obergeschoss | 1.06018e-16 | 0.052
 | Erdgeschoss | 1.23688e-16 | 1.50351
 | Erdgeschoss | 1 | 2.975
4 x  | Erdgeschoss | 1 | 0.2345
 | Erdgeschoss | 7.79634e-17 | 0.768499
4 x  | Obergeschoss | 0.5 | 0.0853051
2 x  | Erdgeschoss | 7.79634e-17 | 0.0670547
2 x  | Erdgeschoss | 2.24972e-32 | 0.0670547
 | Obergeschoss | 7.79634e-17 | 0.0070254
 | Erdgeschoss | 7.79634e-17 | 0.79466
 | Erdgeschoss | 1 | 3.986
 | Erdgeschoss | 7.79634e-17 | 0.673893
 | Erdgeschoss | 7.79634e-17 | 0.0996642
 | Erdgeschoss | 8.97488e-19 | 0.000256196
 | Erdgeschoss | 0 | 0.335414
2 x  | Erdgeschoss | 0.5 | 0.0853051
 | Erdgeschoss | 1.06018e-16 | 0.052
 | Erdgeschoss | 7.79634e-17 | 0.0070254
4 x  | Obergeschoss | 2.24972e-32 | 0.0670547
 | Erdgeschoss | 7.79634e-17 | 1.49411
 | Erdgeschoss | 7.79634e-17 | 2.172
 | Erdgeschoss | 3.89817e-17 | 3.33489
 | Erdgeschoss | 8.97721e-19 | 0.130941
 | Erdgeschoss | 1.01424e-14 | 0.0186174
 | Erdgeschoss | 0 | 0.0325109
2 x  | Obergeschoss | 7.79634e-17 | 0.673893
2 x  | Obergeschoss | 1 | 2.975
8 x  | Obergeschoss | 1 | 0.2345
 | Obergeschoss | 7.79634e-17 | 1.03506
 | Obergeschoss | 7.79634e-17 | 0.145333
2 x  | Obergeschoss | 8.97721e-19 | 0.130941
 | Obergeschoss | 3.89817e-17 | 3.32639
2 x  | Obergeschoss | 7.79634e-17 | 0.0996642
2 x  | Obergeschoss | 7.79634e-17 | 2.172
2 x  | Obergeschoss | 8.97488e-19 | 0.000256196
 | Obergeschoss | 1 | 3.9775
2 x  | Obergeschoss | 7.79634e-17 | 1.49411
2 x  | Obergeschoss | 7.79634e-17 | 0.79466
2 x  | Obergeschoss | 0 | 0.335414
2 x  | Obergeschoss | 0 | 0.0325109
 | Erdgeschoss | 7.79634e-17 | 0.433117
2 x  | Obergeschoss | 1 | 3.025
 | Obergeschoss | 6.33945e-17 | 3.55271e-15
 | Obergeschoss | 7.79634e-17 | 0.385947
 | Erdgeschoss | 6.33945e-17 | 3.55271e-15
 | Obergeschoss | 6.33945e-17 | 5.0243e-15
 | Obergeschoss | 7.79634e-17 | 0.433117
 | Obergeschoss | 7.79634e-17 | 0.204797
 | Obergeschoss | 3.89817e-17 | 3.33489
 | Erdgeschoss | 1 | 3.025
 | Obergeschoss | 1 | 3.986
2 x  | Obergeschoss | 1.01424e-14 | 0.0186174
 | Erdgeschoss | 7.79634e-17 | 0.62
 | Obergeschoss | 0 | 0.0070254

# IfcPipeSegment: Kupferrohre in Stangen 5 m, 28 x 1,5 mm (147)
Type - PredefinedType: RIGIDSEGMENT; Material: layer 0.0015 m
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SS091209006; Manufacturer: DDScad
Type - Pset_PipeSegmentTypeCommon - NominalDiameter: 0.025 m; InnerDiameter: 0.025 m; OuterDiameter: 0.028 m
Name | In | Gradient | Length (m)
2 x  | Obergeschoss | 1 | 2.525
 | Obergeschoss | 4.44392e-15 | 2.255
 | Obergeschoss | 4.08041e-31 | 0.983337
 | Obergeschoss | 4.28799e-15 | 3.18568
 | Obergeschoss | 1 | 0.381
 | Erdgeschoss | 1 | 3.981
 | Erdgeschoss | 7.79634e-17 | 2.255
 | Erdgeschoss | 3.13878e-32 | 0.983337
 | Erdgeschoss | 1 | 2.525
 | Erdgeschoss | 3.89817e-17 | 2.22087
 | Erdgeschoss | 7.79634e-17 | 3.18568
 | Erdgeschoss | 0 | 0.369325
8 x  | Erdgeschoss | 1 | 0.0895
 | Erdgeschoss | 3.89817e-17 | 0.973816
 | Erdgeschoss | 7.79634e-17 | 1.2049
2 x  | Obergeschoss | 1.06018e-16 | 0.125605
 | Erdgeschoss | 2.24972e-32 | 0.0174833
2 x  | Obergeschoss | 1.23688e-16 | 0.580614
 | Erdgeschoss | 1.06018e-16 | 0.125605
4 x  | Obergeschoss | 0.5 | 0.0396444
 | Erdgeschoss | 1 | 1.125
 | Erdgeschoss | 7.79634e-17 | 0.624359
4 x  | Erdgeschoss | 1 | 0.3795
 | Erdgeschoss | 1.23688e-16 | 0.580614
 | Erdgeschoss | 6.33945e-17 | 0.00624474
2 x  | Erdgeschoss | 0 | 0.00624474
 | Erdgeschoss | 7.79634e-17
 | Erdgeschoss | 5.02204e-31 | 0.10658
 | Erdgeschoss | 1.55927e-16 | 0.59618
 | Obergeschoss | 3.89817e-17 | 2.1737
2 x  | Erdgeschoss | 0.5 | 0.0396444
 | Obergeschoss | 5.06762e-15 | 2.19554
 | Obergeschoss | 1 | 3.9625
 | Obergeschoss | 3.89817e-17 | 1.00249
 | Obergeschoss | 5.33592e-31 | 0.983337
 | Obergeschoss | 7.79634e-17 | 1.26437
8 x  | Obergeschoss | 1 | 0.3795
 | Erdgeschoss | 3.89817e-17 | 0.00624474
2 x  | Obergeschoss | 6.33945e-17 | 0.00624474
 | Obergeschoss | 4.9117e-15 | 3.18568
2 x  | Obergeschoss | 0 | 0.00624474
2 x  | Obergeschoss | 1.55927e-16 | 0.59618
 | Obergeschoss | 4.46284e-22 | 0.10658
8 x  | Obergeschoss | 1 | 0.0895
2 x  | Obergeschoss | 1 | 1.075
 | Obergeschoss | 6.33945e-17 | 0.0886322
 | Obergeschoss | 1.55927e-16 | 0.824861
 | Erdgeschoss | 0 | 0.225004
 | Obergeschoss | 2.51102e-31 | 0.225004
2 x  | Obergeschoss | 1 | 1.125
 | Obergeschoss | 3.13878e-32 | 0.0886322
2 x  | Erdgeschoss | 0
2 x  | Obergeschoss | 3.89817e-17 | 0.00624474
2 x  | Obergeschoss | 9.41633e-32
 | Erdgeschoss | 0 | 0.0886322
 | Obergeschoss | 6.33707e-17 | 2.96346
 | Obergeschoss | 1.78051e-29 | 0.220023
 | Erdgeschoss | 1 | 1.075
 | Erdgeschoss | 6.98803e-31 | 0.220023
 | Erdgeschoss | 0 | 0.0928993
 | Obergeschoss | 0 | 0.547745
 | Obergeschoss | 6.33945e-17 | 0.0928993
 | Obergeschoss | 3.13878e-32 | 0.0928993
2 x  | Obergeschoss | 1 | 0.105
 | Obergeschoss | 2.8249e-31 | 0.0708307
 | Obergeschoss | 0 | 0.902858
 | Obergeschoss | 1.52795e-19 | 0
 | Obergeschoss | 5.31175e-16 | 0.661188
 | Obergeschoss | 0 | 0.44292
 | Obergeschoss | 6.17781e-17 | 0.0844054
 | Erdgeschoss | 6.33945e-17 | 0.0886322
 | Erdgeschoss | 0 | 0.0075
 | Obergeschoss | 7.79634e-17
 | Erdgeschoss | 1.55927e-16 | 0.824861
 | Erdgeschoss | 6.33945e-17 | 0.0928993
 | Erdgeschoss | 6.33945e-17 | 2.96346
 | Erdgeschoss | 2.24972e-32 | 0.0134383
 | Obergeschoss | 7.79634e-17 | 0.0337551
 | Erdgeschoss | 7.79634e-17 | 0.0134383
 | Erdgeschoss | 1 | 0.105
 | Erdgeschoss | 7.79634e-17 | 0.81592
 | Obergeschoss | 6.33945e-17 | 0.0584833
 | Erdgeschoss | 6.33945e-17 | 0.0590833
 | Obergeschoss | 2.19714e-31 | 0.0075
 | Obergeschoss | 3.06031e-31 | 0.0174833
 | Obergeschoss | 4.44392e-15 | 0.609359
 | Obergeschoss | 4.28799e-15 | 0.0134383
 | Erdgeschoss | 1.55927e-16 | 0.590955
 | Obergeschoss | 7.79634e-17 | 0.0134383
 | Obergeschoss | 1.56708e-29 | 0.742001
 | Obergeschoss | 4.44392e-15 | 0.81592
 | Erdgeschoss | 7.79634e-17 | 0.0174833
 | Obergeschoss | 1.55927e-16 | 0.39014
 | Obergeschoss | 1.56708e-29 | 0.440861
 | Obergeschoss | 6.33931e-17 | 2.98427
 | Obergeschoss | 1.56708e-29 | 0.517023
 | Obergeschoss | 3.06031e-31 | 0.0134383
 | Obergeschoss | 2.78826e-23 | 0.10658
2 x  | Obergeschoss | 3.13878e-32 | 0.00624474
 | Obergeschoss | 1.88327e-31 | 0.225004
 | Obergeschoss | 7.79634e-17 | 1.2049
 | Erdgeschoss | 1 | 0.381
 | Obergeschoss | 1 | 3.981
 | Obergeschoss | 3.89817e-17 | 0.973816
 | Obergeschoss | 3.89817e-17 | 2.22087

# IfcSanitaryTerminal: Handwaschbecken, 45 x 35,5 cm (12)
Type - PredefinedType: WASHHANDBASIN
Type - Pset_ManufacturerTypeInformation - ArticleNumber: BSN40/45; Manufacturer: DDScad
Name | In
4 x -1 | Obergeschoss
2 x -19 | Erdgeschoss
2 x -1 | Erdgeschoss
4 x -19 | Obergeschoss

# IfcSanitaryTerminal: Stand WC, mit aufgesetztem Spülkasten (3)
Type - PredefinedType: TOILETPAN
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WC-160417-037; Manufacturer: DDScad
Type - Pset_SanitaryTerminalTypeToiletPan - ToiletType: CLOSECOUPLED
Name | In
2 x -1 | Obergeschoss
-1 | Erdgeschoss

# IfcSanitaryTerminal: Urinal Keramik (9)
Type - PredefinedType: URINAL
Type - Pset_ManufacturerTypeInformation - ArticleNumber: UR001; Manufacturer: DDScad
Name | In
6 x  | Obergeschoss
3 x  | Erdgeschoss

# IfcSanitaryTerminal: Wand WC, Tiefspüler, mit eingebautem Spülkasten (15)
Type - PredefinedType: TOILETPAN
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WC-160417-007; Manufacturer: DDScad
Type - Pset_SanitaryTerminalTypeToiletPan - ToiletType: CLOSECOUPLED
Name | In
5 x -1 | Erdgeschoss
10 x -1 | Obergeschoss

# IfcSanitaryTerminal: Waschtisch rechteckig 60 x 46,5 cm (3)
Type - PredefinedType: WASHHANDBASIN
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SIN654; Manufacturer: DDScad
Name | In
-0 | Erdgeschoss
2 x -0 | Obergeschoss

# IfcValve: Dachentlüftungsventil DN 100 (3)
In: Dachaufsicht
Type - PredefinedType: AIRRELEASE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E1-20120102-006; Manufacturer: DDScad
