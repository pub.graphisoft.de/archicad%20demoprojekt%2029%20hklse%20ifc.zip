Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option: [Keine IfcSpaces: On], Option: [Keine Kabel: On], Option [Gebäude: Off], Option [Elektrotechnik: Off], Option [Heizung: Off], Option [Sanitär: Off], Option [Brandschutz: Off], Option [Kälte: Off], Option [Klima/Lüftung: Off], Option [Provision for Void: On]
File name: 20250704_Demoprojekt_Pfv.ifc
Time: 2025-07-07T17:33:18
Author: onedr
Organization: 123
Written by: DDS_IFC v3.0
Made in: DDScad MEP Version 20 x64 build 20/11-2024
Authorization: DDS

# IfcProject, Archicad Demoprojekt Bürogebäude
Description: Demodatei eines Bürogebäudes mit Verkaufsfläche

# IfcSite, Grundstück
RefLatitude: 51, 47, 22, 999999; RefLongitude: 7, 37, 12, 999999; RefElevation: 62 m
Pset_LandRegistration - IsPermanentID: no

# IfcBuilding, DDScad-Demoprojekt-Buero-18
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (6)
In: DDScad-Demoprojekt-Buero-18
Name | Description | Elevation (m)
Erdgeschoss | Erdgeschoss | 0
Fundament | Fundament | -5.3
Obergeschoss | Obergeschoss | 4.4
Dachaufsicht | Dachaufsicht | 13.2
Obergeschoss | Obergeschoss | 8.8
Untergeschoss | Untergeschoss | -3.5

# IfcBuildingElementProxy: Fußbodendurchbruch rechteckig
In: Obergeschoss
Type - PredefinedType: PROVISIONFORVOID
Pset_BuildingElementProxyProvisionForVoid - Shape: Rectangle; Width: 1.768 m; Height: 0.2 m; Depth: 0.3 m; System: Heizung, Sanitär, Lüftung, Kälte
ePset_DB - ARC Freigegeben: yes; Art: H/S/L/K; Kommentar: X; TWP Freigegeben: no; Type: BD

# IfcBuildingElementProxy: Fußbodendurchbruch rund (3)
In: Obergeschoss
Type - PredefinedType: PROVISIONFORVOID
Pset_BuildingElementProxyProvisionForVoid - Shape: Round; Depth: 0.3 m; System: Sanitär
ePset_DB - ARC Freigegeben: yes; Art: S; Kommentar: X; TWP Freigegeben: no; Type: BD
Name | Diameter (m)
2 x Fußbodendurchbruch rund | 0.15
Fußbodendurchbruch rund | 0.1

# IfcBuildingElementProxy: Wanddurchbruch rechteckig (56)
Type - PredefinedType: PROVISIONFORVOID
Pset_BuildingElementProxyProvisionForVoid - Shape: Rectangle
Name | In | Width (m) | Height (m) | Depth (m) | System | ARC Freigegeben | Art | Kommentar | TWP Freigegeben | Type
Wanddurchbruch rechteckig | Obergeschoss | 0.473371 | 0.138 | 0.1 | Kälte | yes | K | X | no | WD
2 x Wanddurchbruch rechteckig | Obergeschoss | 0.520286 | 0.145 | 0.1 | Heizung | yes | H | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.461778 | 0.138018 | 0.1 | Kälte | yes | K | X | no | WD
12 x Wanddurchbruch rechteckig | Obergeschoss | 0.4 | 0.088 | 0.1 | Elektro | yes | E | X | no | WD
2 x Wanddurchbruch rechteckig | Obergeschoss | 0.443245 | 0.138 | 0.1 | Kälte | yes | K | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.449964 | 0.138007 | 0.1 | Kälte | yes | K | X | no | WD
2 x Wanddurchbruch rechteckig | Obergeschoss | 0.145 | 0.145 | 0.1 | Heizung | yes | H | X | no | WD
3 x Wanddurchbruch rechteckig | Obergeschoss | 0.412029 | 0.145 | 0.1 | Heizung | yes | H | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.35 | 0.105 | 0.1 | Elektro | yes | E | X | no | WD
2 x Wanddurchbruch rechteckig | Obergeschoss | 0.35 | 0.105 | 0.2 | Elektro | yes | E | X | no | WD
3 x Wanddurchbruch rechteckig | Obergeschoss | 0.35 | 0.038 | 0.1 | Elektro | yes | E | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.356197 | 0.038 | 0.2 | Elektro | yes | E | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.551141 | 0.5 | 0.1 | Lüftung | yes | L | X | no | WD
Wanddurchbruch rechteckig | Untergeschoss | 0.607095 | 0.3 | 0.175
Wanddurchbruch rechteckig | Untergeschoss | 0.530582 | 0.152 | 0.175
Wanddurchbruch rechteckig | Untergeschoss | 0.238 | 0.138 | 0.4
Wanddurchbruch rechteckig | Obergeschoss | 0.879461 | 0.895 | 0.1 | Heizung, Kälte | yes | H/K | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.323366 | 0.108 | 0.1 | Sanitär | yes | S | X | no | WD
Wanddurchbruch rechteckig | Untergeschoss | 0.607095 | 0.3 | 0.2
Wanddurchbruch rechteckig | Obergeschoss | 0.293013 | 0.108 | 0.1 | Sanitär | yes | S | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.723459 | 0.145 | 0.1 | Heizung, Kälte | yes | H/K | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.551141 | 0.2 | 0.3 | Lüftung | yes | L | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.879461 | 0.145 | 0.1 | Heizung, Kälte | yes | H/K | X | no | WD
2 x Wanddurchbruch rechteckig | Obergeschoss | 0.849461 | 0.145 | 0.1 | Heizung, Kälte | yes | H/K | X | no | WD
Wanddurchbruch rechteckig | Untergeschoss | 0.424467 | 0.152 | 0.2
Wanddurchbruch rechteckig | Obergeschoss | 0.382029 | 0.145 | 0.1 | Heizung | yes | H | X | no | WD
3 x Wanddurchbruch rechteckig | Obergeschoss | 0.398325 | 0.145 | 0.1 | Heizung | yes | H | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.35 | 0.038 | 0.1
Wanddurchbruch rechteckig | Obergeschoss | 0.306693 | 0.088 | 0.1 | Kälte | yes | K | X | no | WD
2 x Wanddurchbruch rechteckig | Obergeschoss | 0.723459 | 0.145 | 0.2 | Heizung, Kälte | yes | H/K | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.195 | 0.095 | 0.1 | Heizung | yes | H | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.245 | 0.145 | 0.1 | Heizung | yes | H | X | no | WD
Wanddurchbruch rechteckig | Obergeschoss | 0.256693 | 0.088 | 0.1 | Kälte | yes | K | X | no | WD

# IfcBuildingElementProxy: Wanddurchbruch rund (15)
Type - PredefinedType: PROVISIONFORVOID
Pset_BuildingElementProxyProvisionForVoid - Shape: Round
Name | In | Diameter (m) | Depth (m)
3 x Wanddurchbruch rund | Obergeschoss | 0.2 | 0.1 | Pset_BuildingElementProxyProvisionForVoid - System: Lüftung; ePset_DB - ARC Freigegeben: yes; Art: L; Kommentar: X; TWP Freigegeben: no; Type: WD
Wanddurchbruch rund | Obergeschoss | 0.2 | 0.3 | Pset_BuildingElementProxyProvisionForVoid - System: Lüftung; ePset_DB - ARC Freigegeben: yes; Art: L; Kommentar: X; TWP Freigegeben: no; Type: WD
Wanddurchbruch rund | Obergeschoss | 0.2 | 0.03 | Pset_BuildingElementProxyProvisionForVoid - System: Lüftung; ePset_DB - ARC Freigegeben: yes; Art: L; Kommentar: X; TWP Freigegeben: no; Type: WD
2 x Wanddurchbruch rund | Untergeschoss | 0.138 | 0.175
2 x Wanddurchbruch rund | Untergeschoss | 0.3 | 0.4
2 x Wanddurchbruch rund | Untergeschoss | 0.152 | 0.4
2 x Wanddurchbruch rund | Untergeschoss | 0.138 | 0.2
Wanddurchbruch rund | Untergeschoss | 0.146553 | 0.4
Wanddurchbruch rund | Untergeschoss | 0.138326 | 0.2
