Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option: [Keine IfcSpaces: On], Option: [Keine Kabel: On], Option [Gebäude: Off], Option [Elektrotechnik: On], Option [Heizung: Off], Option [Sanitär: Off], Option [Brandschutz: Off], Option [Kälte: Off], Option [Klima/Lüftung: Off], Option [Provision for Void: Off]
File name: 20250704_Demoprojekt_ELT.ifc
Time: 2025-07-08T09:56:46
Author: onedr
Organization: 123
Written by: DDS_IFC v3.0
Made in: DDScad MEP Version 20 x64 build 20/11-2024
Authorization: DDS

# IfcProject, Archicad Demoprojekt Bürogebäude
Description: Demodatei eines Bürogebäudes mit Verkaufsfläche

# IfcSite, Grundstück
RefLatitude: 51, 47, 22, 999999; RefLongitude: 7, 37, 12, 999999; RefElevation: 62 m
Pset_LandRegistration - IsPermanentID: no

# IfcBuilding, DDScad-Demoprojekt-Buero-18
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (6)
In: DDScad-Demoprojekt-Buero-18
Name | Description | Elevation (m)
Obergeschoss | Obergeschoss | 8.8
Obergeschoss | Obergeschoss | 4.4
Untergeschoss | Untergeschoss | -3.5
Erdgeschoss | Erdgeschoss | 0
Fundament | Fundament | -5.3
Dachaufsicht | Dachaufsicht | 13.2

# IfcActuator: KNX-Schaltaktor 4-fach 16A REG 4 TE, A4
In: Obergeschoss
Type - PredefinedType: ELECTRICACTUATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDA-120215-007; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 16; NumberOfPoles: 4204; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
DDS_Pset_ElectroComponents - Characteristic: 16A

# IfcActuator: KNX-Schaltaktor 8-fach 16A REG 8 TE (2)
In: Obergeschoss
Type - PredefinedType: ELECTRICACTUATOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDA-120215-013; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 16; NumberOfPoles: 4208; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
DDS_Pset_ElectroComponents - Characteristic: 16A
Name
A2
A3

# IfcBuildingElementProxy: Fangstange l=0,75m (7)
In: Dachaufsicht
Type - ElementType: LIGHTNINGPROTECTION; PredefinedType: USERDEFINED
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LP-031008-008; Manufacturer: DDScad
Name
2 x -19
4 x -0
-1

# IfcBuildingElementProxy: Fangstange l=1,5m (10)
In: Dachaufsicht
Type - ElementType: LIGHTNINGPROTECTION; PredefinedType: USERDEFINED
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LP-260523091721; Manufacturer: DDScad

# IfcCableCarrierFitting: Bogen Fußbodenkanal, 350 x 38mm
In: Obergeschoss
Type - PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WB-180228-085; Manufacturer: DDScad

# IfcCableCarrierFitting: Bogen LF-Kanal 60 x 90mm
In: Untergeschoss
Type - PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WB-180217-052; Manufacturer: DDScad

# IfcCableCarrierFitting: Bogen LF-Kanal 60 x 90mm, Innenecke
In: Untergeschoss
Type - PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WB-180217-053; Manufacturer: DDScad

# IfcCableCarrierFitting: Bogen für Kabelrinne, Höhe 55 mm, Breite 300 mm (12)
Type - PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QA-180219-013; Manufacturer: DDScad
IFC4X3_ADD2_Pset_FittingBend - BendRadius: 0.05 m; BendAngle: 1.5708 rad
Name | In
8 x  | Obergeschoss
4 x  | Erdgeschoss

# IfcCableCarrierFitting: Fußbodenkanaldose mit Blinddeckel max 350 mm Breite (4)
In: Obergeschoss
Type - PredefinedType: CROSS
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WT-130131-013; Manufacturer: DDScad

# IfcCableCarrierFitting: Fußbodenkanaldose mit Geräte-Einsatz für 7 Geräte rund max 350 mm Breite (15)
In: Obergeschoss
Type - PredefinedType: CROSS
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WT-130131-009; Manufacturer: DDScad
Name
8 x 
5 x -0
2 x -1

# IfcCableCarrierFitting: T-Abgang für Kabelrinne, Höhe 55 mm, Breite 300 mm > Abgang 300 mm (6)
Type - ElementType: JUNCTION; PredefinedType: USERDEFINED
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QT-180219-040; Manufacturer: DDScad
IFC4X3_ADD2_Pset_FittingJunction - JunctionType: TEE
Name | In
4 x  | Obergeschoss
2 x  | Erdgeschoss

# IfcCableCarrierFitting: T-Abgang für Steigtrasse leicht, Höhe 60 mm, Breite 500 mm > Abgang 500 mm (2)
Type - ElementType: JUNCTION; PredefinedType: USERDEFINED
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QT-180110-886; Manufacturer: DDScad
IFC4X3_ADD2_Pset_FittingJunction - JunctionType: TEE
Name | In
 | Erdgeschoss
 | Untergeschoss

# IfcCableCarrierFitting: Winkel für Steigtrasse leicht, Höhe 60 mm, Breite 500 mm (2)
In: Erdgeschoss
Type - PredefinedType: BEND
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QA-180108-305; Manufacturer: DDScad
IFC4X3_ADD2_Pset_FittingBend - BendRadius: 0.15 m; BendAngle: 1.5708 rad

# IfcCableCarrierSegment: Fußbodenkanal, Breite 350mm x Höhe 38mm (26)
In: Obergeschoss
Type - PredefinedType: CABLETRUNKINGSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WS-030916-065; Manufacturer: DDScad
Type - Pset_CableCarrierSegmentTypeCableTrunkingSegment - NominalWidth: 0.35 m; NominalHeight: 0.038 m
Name | Length (m)
5 x  | 14.8975
2 x  | 8.17505
3 x  | 8.76375
 | 10.6046
 | 0.824141
 | 5.52237
 | 3.97502
 | 9.61636
 | 6.30875
 | 8.08169
 | 0.778773
 | 5.45375
 | 5.51
 | 2.17502
 | 5.48498
 | 10.4296
 | 0.999142
 | 0.811449
 | 5.22559

# IfcCableCarrierSegment: Kabelrinne, Höhe 55 mm, Breite 300 mm (22)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QL-180219-008; Manufacturer: DDScad
Type - Pset_CableCarrierSegmentTypeCableTraySegment - NominalWidth: 0.3 m; NominalHeight: 0.055 m
Name | In | Length (m)
4 x  | Obergeschoss | 5.4875
4 x  | Obergeschoss | 8.875
4 x  | Obergeschoss | 16.7875
 | Obergeschoss | 8.775
2 x  | Erdgeschoss | 16.7875
 | Obergeschoss | 5.80136
2 x  | Erdgeschoss | 8.875
2 x  | Erdgeschoss | 5.4875
 | Obergeschoss | 2.97364
 | Erdgeschoss | 8.775

# IfcCableCarrierSegment: Kunststoff-Isolierrohr DN-16 FBY-EL, wellig, leicht (5)
In: Obergeschoss
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: RO-041008-001; Manufacturer: DDScad
Type - Pset_CableCarrierSegmentTypeConduitSegment - NominalWidth: 0.016 m
Qto_CableCarrierSegmentBaseQuantities - Length: 1.71983 m

# IfcCableCarrierSegment: LF-Kanal, Höhe 60mm x Breite 90mm (3)
In: Untergeschoss
Type - PredefinedType: CABLETRUNKINGSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: WS-180212-018; Manufacturer: DDScad
Type - Pset_CableCarrierSegmentTypeCableTrunkingSegment - NominalWidth: 0.09 m; NominalHeight: 0.06 m
Name | Length (m)
 | 2.03676
 | 1.75978
 | 2.69158

# IfcCableCarrierSegment: Steigtrasse leicht, Höhe 60 mm, Breite 500 mm (12)
Type - PredefinedType: CABLELADDERSEGMENT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QL-180102-144; Manufacturer: DDScad
Type - Pset_CableCarrierSegmentTypeCableLadderSegment - NominalWidth: 0.5 m; NominalHeight: 0.06 m
Name | In | Length (m)
 | Untergeschoss | 3.05
 | Obergeschoss | 4.7
 | Erdgeschoss | 0.208014
 | Untergeschoss | 0.63051
 | Erdgeschoss | 0.319986
 | Erdgeschoss | 0.169245
 | Erdgeschoss | 3.53601
 | Untergeschoss | 0.614501
 | Obergeschoss | 3.4
 | Obergeschoss | 0.3
 | Obergeschoss | 0.6
 | Erdgeschoss

# IfcDiscreteAccessory: Kabelbahnhalter, Wandmontage, T Form, W=300 mm (51)
In: Obergeschoss
Type - PredefinedType: BRACKET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: QS-220219-018; Manufacturer: DDScad

# IfcDistributionCircuit (122)
PredefinedType: ELECTRICAL
Pset_DistributionSystemTypeElectrical - ElectricalSystemCategory: LOWVOLTAGE
Name | Description | Diversity | NumberOfLiveConductors | MaximumAllowedVoltageDrop (V) | NetImpedance (ohm)
2 x 1 | Einspeisung | 1 | 3 | 12 | Pset_DistributionSystemTypeElectrical - ElectricalSystemType: TN_S; DDS_Pset_CircuitLoad - LoadPhaseL1: 38.4 A; LoadPhaseL2: 38.4 A; LoadPhaseL3: 38.4 A; isEmergencySwitchoverCircuit: no
4 x 1 | Einspeisung | 1 | 3 | 12 | Pset_DistributionSystemTypeElectrical - ElectricalSystemType: TN_S; DDS_Pset_CircuitLoad - LoadPhaseL1: 0 A; LoadPhaseL2: 0 A; LoadPhaseL3: 0 A; isEmergencySwitchoverCircuit: no
1 | Einspeisung | 1 | 3 | 12 | Pset_DistributionSystemTypeElectrical - ElectricalSystemType: TN_S; DDS_Pset_CircuitLoad - LoadPhaseL1: 525.562 A; LoadPhaseL2: 531.397 A; LoadPhaseL3: 565.452 A; isEmergencySwitchoverCircuit: no
3 x 25 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 3 | Licht | 0.3 | 1 | 6.9 | 0.3
34 | Steckdose | 1 | 1 | 6.9 | 0.3
3 x 6 | Licht | 0.3 | 1 | 6.9 | 0.3
42 | Steckdose | 1 | 1 | 6.9 | 0.3
44 | Steckdose | 1 | 1 | 6.9 | 0.3
36 | Steckdose | 1 | 1 | 6.9 | 0.3
43 | Steckdose | 1 | 1 | 6.9 | 0.3
35 | Steckdose 2OG-10 Meeting | 1 | 1 | 6.9 | 0.3
40 | Steckdose | 1 | 1 | 6.9 | 0.3
33 | Steckdose | 1 | 1 | 6.9 | 0.3
3 x 24 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 26 | Licht | 0.3 | 1 | 6.9 | 0.3
37 | Steckdose | 1 | 1 | 6.9 | 0.3
41 | Steckdose | 1 | 1 | 6.9 | 0.3
1 | Einspeisung | 1 | 3 | 12 | Pset_DistributionSystemTypeElectrical - ElectricalSystemType: TN_S; DDS_Pset_CircuitLoad - LoadPhaseL1: 21.4409 A; LoadPhaseL2: 27.3965 A; LoadPhaseL3: 65.2348 A; isEmergencySwitchoverCircuit: no
31 | KNX Bus Linie | 0.3 | 0 | 0 | 0.3
3 x 2 | Vorsicherung RCD | 1 | 3 | 12 | 0
3 x 4 | Licht | 0.3 | 1 | 6.9 | 0.3
2 x 9 | Vorsicherung RCD | 1 | 3 | 12 | 0
3 x 7 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 11 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 5 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 10 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 13 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 12 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 14 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 15 | Licht | 0.3 | 1 | 6.9 | 0.3
2 x 16 | Vorsicherung RCD | 1 | 3 | 12 | 0
3 x 18 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 17 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 20 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 19 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 21 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 22 | Licht | 0.3 | 1 | 6.9 | 0.3
2 x 23 | Vorsicherung RCD | 1 | 3 | 12 | 0
3 x 29 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 28 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 27 | Licht | 0.3 | 1 | 6.9 | 0.3
3 x 8 | Licht | 0.3 | 1 | 6.9 | 0.3
2 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
3 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
4 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
5 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
1 | Einspeisung | 1 | 3 | 12 | Pset_DistributionSystemTypeElectrical - ElectricalSystemType: TN_S; DDS_Pset_CircuitLoad - LoadPhaseL1: 504 A; LoadPhaseL2: 504 A; LoadPhaseL3: 504 A; isEmergencySwitchoverCircuit: no
6 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
7 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
8 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
9 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 63 A; LoadPhaseL2: 63 A; LoadPhaseL3: 63 A; isEmergencySwitchoverCircuit: no
10 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 0 A; LoadPhaseL2: 0 A; LoadPhaseL3: 0 A; isEmergencySwitchoverCircuit: no
2 | Zuleitung zu UV | 1 | 3 | 12 | 0.3 | DDS_Pset_CircuitLoad - LoadPhaseL1: 525.562 A; LoadPhaseL2: 531.397 A; LoadPhaseL3: 565.452 A; isEmergencySwitchoverCircuit: no
9 | Vorsicherung RCD | 1 | 3 | 12 | 0.3
16 | Vorsicherung RCD | 1 | 3 | 12 | 0.3
23 | Vorsicherung RCD | 1 | 3 | 12 | 0.3
32 | Vorsicherung RCD | 1 | 3 | 12 | 0
38 | Steckdose | 1 | 1 | 6.9 | 0.3
39 | Vorsicherung RCD | 1 | 3 | 12 | 0
45 | Steckdose | 1 | 1 | 6.9 | 0.3
30 |  | 0.3 | 1 | 6.9 | 0
2 | Brandmeldeanlage | 1 | 1 | 0 | 0
1 | Brandmeldeanlage | 1 | 1 | 0 | 0
30 | KNX Spg.Versorgung | 0.3 | 1 | 6.9 | 0

# IfcDistributionPort (1670)
Name | FlowDirection | PredefinedType | SystemType
385 x  | SOURCE | CABLE | ELECTRICAL
941 x  | SINK | CABLE | ELECTRICAL
124 x  |  | CABLECARRIER
170 x  |  | CABLECARRIER | ELECTRICAL
48 x  |  | CABLE | ELECTRICAL
2 x  |  | CABLE | LIGHTING

# IfcDistributionSystem: #BMA (2)
PredefinedType: FIREPROTECTION
Name
BMZ
Brandmelde

# IfcDistributionSystem: #POWERRISER, Energieversorgung - Verteilerschema
PredefinedType: ELECTRICAL; Group: Energieversorgung - Übersichtsschaltplan

# IfcDistributionSystem: #SINGLELINE, Energieversorgung - Übersichtsschaltplan
PredefinedType: ELECTRICAL

# IfcElectricDistributionBoard: 5t-Zählerschrank 1250x1300x205, ZA
In: Untergeschoss
Type - PredefinedType: CONSUMERUNIT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SB-030916-015; Manufacturer: DDScad

# IfcElectricDistributionBoard: Brandmelde-Zentrale, BMZ
In: Untergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SB-020812-011; Manufacturer: DDScad
Group: BMZ

# IfcElectricDistributionBoard: Hausanschlusskasten, HAK
In: Untergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SB-020812-023; Manufacturer: DDScad
Group: 1

# IfcElectricDistributionBoard: Netzwerkschrank 80x80x220 47HE (4)
Type - PredefinedType: SWITCHBOARD
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SB-010213-023; Manufacturer: DDScad
Group: 1
Name | In
Daten 1.OG | Obergeschoss
Daten EG | Erdgeschoss
Daten 2.OG-Kopie | Obergeschoss
VA-Vortragssaal-Kopie | Obergeschoss

# IfcElectricDistributionBoard: Verteilerschrank 800x 800x275 180 TE (3)
Type - PredefinedType: CONSUMERUNIT
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SB-030916-035; Manufacturer: DDScad
Group: 1
Name | In
UV 1.OG | Obergeschoss
UV EG | Erdgeschoss
UV 2.OG-Kopie | Obergeschoss

# IfcFlowMeter: Zähler kWh 3-pol. elektr. Hauszähler (eHZ) (9)
In: Untergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDP-080911-001; ModelReference: eHZ; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 63; NumberOfPoles: 0
DDS_Pset_ElectroComponents - Characteristic: 63A
Name | Group
P1 | 2
P2 | 3
P3 | 4
P4 | 5
P5 | 6
P6 | 7
P7 | 8
P8 | 9
P9 | 10

# IfcJunctionBox: Dose, rund, Öffnung 60mm, Tiefe 66mm, 4x Anschlüsse seitwärts, Leerrohr max. DN 25 (5)
In: Obergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: TB-190613-002; Manufacturer: DDScad
Type - Pset_JunctionBoxTypeCommon - MountingType: NOTKNOWN; ShapeType: NOTKNOWN; PlacingType: WALL
Name
12
13
15
14
11

# IfcLightFixture
In: Obergeschoss
Type - ElementType: Led_strip_rigid_tee; PredefinedType: USERDEFINED
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LV-210208-001; Manufacturer: DDScad
Type - Pset_LightFixtureTypeCommon - LightFixturePlacingType: CEILING
Type - DDS_Qto_BaseQuantities - Width: 10 m; Height: 3 m

# IfcLightFixture
In: Obergeschoss
Type - ElementType: Led_strip_spline; PredefinedType: USERDEFINED
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LE-210208-001; Manufacturer: DDScad
Type - Pset_LightFixtureTypeCommon - TotalWattage: 12 W; LightFixturePlacingType: CEILING
Type - DDS_Qto_BaseQuantities - Width: 10 m; Height: 3 m

# IfcLightFixture: 3m 3-pol. Stromschiene 230/400V In=3x16A (18)
In: Erdgeschoss
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LB-030919-020; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 0; TotalWattage: 0 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 16 A; ActualVoltage: 0 V
Name
16 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
17
15 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
14
12
10
7
3
6
4
9
5
13
11
8
2
19 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
18

# IfcLightFixture: Aufbau-Glasleuchte FR IP43 1x60W, rund 200mm (2)
In: Obergeschoss
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-030918-009; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED; LightFixturePlacingType: CEILING; NumberOfSources: 1; TotalWattage: 60 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.26087 A; ActualVoltage: 0 V; ConnectedConductorFunction: Phase_L1, Neutral, ProtectiveEarth
Group: 6
Name
425
426

# IfcLightFixture: Einspeisung für 3-pol. Stromschiene, Erdleiter links, 230/400V 3x16A (6)
In: Erdgeschoss
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LB-030919-023; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 0; TotalWattage: 0 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 16 A; ActualVoltage: 0 V
Name
25
22
24
21
20
23

# IfcLightFixture: Halogen-Strahler mit Adapter und Trafo 50W, für Stromschienen (39)
In: Erdgeschoss
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-030918-037; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED; LightFixturePlacingType: CEILING; NumberOfSources: 1; TotalWattage: 50 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.217391 A; ActualVoltage: 0 V
Name
390 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
385 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
383
384 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
387 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
389
381
388
386 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
382 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
391 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
379 | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
359
2 x 366
380
373
369
363
362
372
358
370
371
368
367
365
361
355
360
364
354
378
377
375
374
357
356
376

# IfcLightFixture: LED-Aufbauleuchte 24W (30)
Type - PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LF-220315-001; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED; LightFixturePlacingType: CEILING; NumberOfSources: 1; TotalWattage: 24 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.104348 A; ActualVoltage: 0 V
Name | In
2 | Obergeschoss
2 x 22 | Untergeschoss
4 x 21 | Untergeschoss
16 | Untergeschoss
2 | Obergeschoss | DDS_Pset_ElectricalLoadOccurrence - ConnectedConductorFunction: Phase_L2, Neutral, ProtectiveEarth; Group: 25
2 x 18 | Untergeschoss
17 | Untergeschoss
3 | Erdgeschoss
13 | Untergeschoss
20 | Untergeschoss
12 | Untergeschoss
11 | Untergeschoss
2 x 10 | Untergeschoss
8 | Untergeschoss
6 | Untergeschoss
9 | Untergeschoss
5 | Untergeschoss
7 | Untergeschoss
23 | Untergeschoss
3 | Obergeschoss
4 | Obergeschoss
5 | Obergeschoss
15 | Untergeschoss
19 | Untergeschoss

# IfcLightFixture: LED-Einbau-Leuchte 95W eckig 600x600x90mm (58)
In: Obergeschoss
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-130510-013; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED; LightFixturePlacingType: CEILING; NumberOfSources: 1; TotalWattage: 95 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.413043 A; ActualVoltage: 0 V
Name
418
419
419 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
420
399
435
436
382
2 x 384
417
387
2 x 414
416 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
400
2 x 381
415 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
2 x 397
396
394
393
392
398
413
2 x 409
385
410
395
383
412
408
411
2 x 426
386
422
430
2 x 429
428
2 x 423
425
431
427
432
424
371
378
380
370 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
377
368
367

# IfcLightFixture: LED-Einbau-Strahler 31W rund D=150mm H=100mm (158)
In: Obergeschoss
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-130510-011; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED; LightFixturePlacingType: CEILING; NumberOfSources: 1; TotalWattage: 31 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.134783 A; ActualVoltage: 0 V
Name
441
435
451
455
2 x 453
438
437
415
433
417
436
429
454
413
442
416
439
2 x 434
456
440
418
457
452
428
427
431
426
414
430
432
478
2 x 469
2 x 484
2 x 479
476
470
2 x 474
471
475
472
462
480
2 x 464
482
481
460
461
459
463
473
466
467
468
483
458
477
465
487
492 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
494
503 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
490
488
489
519
500
489 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
491
506 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
511 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
512 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
513
501
514 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-09; RoomDescription: Büro
515
505
485
2 x 517
508 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
509 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
516
502 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
404
507 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
395
518
504 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
510 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
493 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
394
520
522
527
486
523
526
547
2 x 410
409
543
532
548
406
551
555
552
521
2 x 554
528
405
525
393
540
553
408
541
542
550
530
529
524
549
558
559
531
579
574
564
562
581
2 x 584
568
2 x 582
575
565
2 x 578
576
567
577
2 x 566
585
573
411
412

# IfcLightFixture: LED-Einbau-Strahler 8,5W rund D=90mm H=60mm (42)
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-130510-005; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED; LightFixturePlacingType: CEILING; NumberOfSources: 1; TotalWattage: 8 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.0347826 A; ActualVoltage: 0 V
Name | In
308 | Obergeschoss
307 | Obergeschoss
306 | Obergeschoss
314 | Obergeschoss
353 | Obergeschoss
352 | Obergeschoss
313 | Obergeschoss
312 | Obergeschoss
309 | Obergeschoss
311 | Obergeschoss
315 | Obergeschoss
316 | Obergeschoss
351 | Obergeschoss
350 | Obergeschoss
310 | Obergeschoss
349 | Obergeschoss
414 | Erdgeschoss
417 | Erdgeschoss
416 | Erdgeschoss
426 | Erdgeschoss
436 | Erdgeschoss
432 | Erdgeschoss
420 | Erdgeschoss
418 | Erdgeschoss
433 | Erdgeschoss
431 | Erdgeschoss
423 | Erdgeschoss
412 | Erdgeschoss
415 | Erdgeschoss
428 | Erdgeschoss
427 | Erdgeschoss
434 | Erdgeschoss
430 | Erdgeschoss
435 | Erdgeschoss
422 | Erdgeschoss
424 | Erdgeschoss
425 | Erdgeschoss
411 | Erdgeschoss
429 | Erdgeschoss
413 | Erdgeschoss
419 | Erdgeschoss
421 | Erdgeschoss

# IfcLightFixture: LED-Panel 1x15W eckig 30x30x40mm (104)
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-230523111215; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED; LightFixturePlacingType: CEILING; NumberOfSources: 3; TotalWattage: 3 W
DDS_Pset_ElectricalLoadOccurrence - ActualVoltage: 0 V
Name | In | ActualCurrent (A)
385 | Obergeschoss | 0.0652174
2 x 388 | Obergeschoss | 0.0652174
384 | Obergeschoss | 0.0652174
2 x 380 | Obergeschoss | 0.0652174
379 | Obergeschoss | 0.0652174
381 | Obergeschoss | 0.0652174
391 | Obergeschoss | 0.0652174
390 | Obergeschoss | 0.0652174
387 | Obergeschoss | 0.0652174
382 | Obergeschoss | 0.0652174
2 x 383 | Obergeschoss | 0.0652174
375 | Obergeschoss | 0.0652174
386 | Obergeschoss | 0.0652174
377 | Obergeschoss | 0.0652174
389 | Obergeschoss | 0.0652174
3 x 439 | Erdgeschoss | 0.0652174
2 x 438 | Erdgeschoss | 0.0652174
440 | Erdgeschoss | 0.0652174
414 | Erdgeschoss | 0.0652174
400 | Erdgeschoss | 0.0652174
407 | Erdgeschoss | 0.0652174
413 | Erdgeschoss | 0.0652174
412 | Erdgeschoss | 0.0652174
436 | Erdgeschoss | 0.0652174
424 | Erdgeschoss | 0.0652174
401 | Erdgeschoss | 0.0652174
406 | Erdgeschoss | 0.0652174
411 | Erdgeschoss | 0.0652174
403 | Erdgeschoss | 0.0652174
397 | Erdgeschoss | 0.0652174
409 | Erdgeschoss | 0.0652174
418 | Erdgeschoss | 0.0652174
417 | Erdgeschoss | 0.0652174
415 | Erdgeschoss | 0.0652174
402 | Erdgeschoss | 0.0652174
416 | Erdgeschoss | 0.0652174
405 | Erdgeschoss | 0.0652174
410 | Erdgeschoss | 0.0652174
399 | Erdgeschoss | 0.0652174
422 | Erdgeschoss | 0.0652174
404 | Erdgeschoss | 0.0652174
423 | Erdgeschoss | 0.0652174
408 | Erdgeschoss | 0.0652174
437 | Erdgeschoss | 0.0652174
420 | Erdgeschoss | 0.0652174
421 | Erdgeschoss | 0.0652174
419 | Erdgeschoss | 0.0652174
398 | Erdgeschoss | 0.0652174
407 | Erdgeschoss | 0.0130435
2 x 402 | Erdgeschoss | 0.0130435
406 | Erdgeschoss | 0.0130435
408 | Erdgeschoss | 0.0130435
401 | Erdgeschoss | 0.0130435
398 | Erdgeschoss | 0.0130435
2 x 405 | Erdgeschoss | 0.0130435
2 x 403 | Erdgeschoss | 0.0130435
400 | Erdgeschoss | 0.0130435
397 | Erdgeschoss | 0.0130435
2 x 396 | Erdgeschoss | 0.0130435
399 | Erdgeschoss | 0.0130435
392 | Erdgeschoss | 0.0130435
404 | Erdgeschoss | 0.0130435
393 | Erdgeschoss | 0.0130435
395 | Erdgeschoss | 0.0130435
2 x 442 | Erdgeschoss | 0.0130435
2 x 443 | Erdgeschoss | 0.0130435
392 | Obergeschoss | 0.0652174
393 | Obergeschoss | 0.0652174
589 | Obergeschoss | 0.0652174
590 | Obergeschoss | 0.0652174
2 x 591 | Obergeschoss | 0.0652174
2 x 588 | Obergeschoss | 0.0652174
586 | Obergeschoss | 0.0652174
587 | Obergeschoss | 0.0652174
592 | Obergeschoss | 0.0652174
593 | Obergeschoss | 0.0652174
584 | Obergeschoss | 0.0652174
604 | Obergeschoss | 0.0652174
2 x 606 | Obergeschoss | 0.0652174
598 | Obergeschoss | 0.0652174
594 | Obergeschoss | 0.0652174
608 | Obergeschoss | 0.0652174
603 | Obergeschoss | 0.0652174
602 | Obergeschoss | 0.0652174
609 | Obergeschoss | 0.0652174
610 | Obergeschoss | 0.0652174
611 | Obergeschoss | 0.0652174
605 | Obergeschoss | 0.0652174
607 | Obergeschoss | 0.0652174

# IfcLightFixture: LED-Pendel-Flächenstrahler 250W 120°, 350
In: Obergeschoss
Type - PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-130510-019; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Type - Pset_LightFixtureTypeCommon - LightFixtureMountingType: SURFACE, SUSPENDED, POLE_SIDE; LightFixturePlacingType: CEILING; NumberOfSources: 1; TotalWattage: 125 W
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.543478 A; ActualVoltage: 0 V; ConnectedConductorFunction: Phase_L1, Neutral, ProtectiveEarth
Group: 3

# IfcOutlet: AP Schukosteckdose 2-fach, 59
In: Erdgeschoss
Type - PredefinedType: POWEROUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SK-110726-012; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 16; NumberOfPoles: 2; HasProtectiveEarth: yes
Type - Pset_OutletTypeCommon - IsPluggableOutlet: yes
DDS_Pset_ElectricalLoadOccurrence - ActualPowerFactor: 1; ActualCurrent: 0.869565 A; ActualVoltage: 0 V

# IfcOutlet: AP Schukosteckdose 3-fach (4)
In: Erdgeschoss
Type - PredefinedType: POWEROUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SK-110726-013; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 16; NumberOfPoles: 2; HasProtectiveEarth: yes
Type - Pset_OutletTypeCommon - IsPluggableOutlet: yes
DDS_Pset_ElectricalLoadOccurrence - ActualPowerFactor: 1; ActualCurrent: 0.869565 A; ActualVoltage: 0 V
Name
57
54
55
58

# IfcOutlet: Daten-Anschlussdose Cat.5 2x RJ45 UP (30)
In: Obergeschoss
Type - PredefinedType: DATAOUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E2-040712-002; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0 A; ActualVoltage: 0 V
Name
5
11 x 6
6 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
7
24
22
23
19 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
16
12
11
14
13
18
15
21
17
20
25
26

# IfcOutlet: Daten-Anschlussdose Cat.7 2x RJ45 UP (2)
In: Obergeschoss
Type - PredefinedType: DATAOUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E2-080908-003; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0 A; ActualVoltage: 0 V
Name
7
9

# IfcOutlet: HDMI - Anschlussdose UP (2)
In: Obergeschoss
Type - PredefinedType: DATAOUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E2-230323105137; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0 A; ActualVoltage: 0 V
Name
8
10

# IfcOutlet: UP 2x USB Buchse (2)
In: Obergeschoss
Type - PredefinedType: POWEROUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SK-140307-002; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 16; NumberOfPoles: 2; HasProtectiveEarth: yes
Type - Pset_OutletTypeCommon - IsPluggableOutlet: yes
DDS_Pset_ElectricalLoadOccurrence - ActualPowerFactor: 1; ActualCurrent: 0.869565 A; ActualVoltage: 0 V
Name
15
16

# IfcOutlet: UP Schukosteckdose 1-fach (92)
In: Obergeschoss
Type - PredefinedType: POWEROUTLET
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SK-030918-001; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 16; NumberOfPoles: 2; HasProtectiveEarth: yes
Type - Pset_OutletTypeCommon - IsPluggableOutlet: yes
DDS_Pset_ElectricalLoadOccurrence - ActualPowerFactor: 1; ActualCurrent: 0.869565 A; ActualVoltage: 0 V
Name | ConnectedConductorFunction | Group
21
2 x 14
20
26
15
25
2 x 45
44
2 x 13
37
39
38
29
28
2 x 7
9
33 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
31 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
6
5
16
27
40
35
41
34
8
30
19
47
46
43
32 | DDS_Pset_RoomPlacement - RoomNumber: 1OG-06; RoomDescription: Büro
42
18
36
17
48
49
50
53 | Phase_L2, Neutral, ProtectiveEarth | 34
58 | Phase_L3, Neutral, ProtectiveEarth | 42
54 | Phase_L2, Neutral, ProtectiveEarth | 34
52 | Phase_L2, Neutral, ProtectiveEarth | 44
55 | Phase_L2, Neutral, ProtectiveEarth | 34
57 | Phase_L3, Neutral, ProtectiveEarth | 42
56 | Phase_L3, Neutral, ProtectiveEarth | 42
34 | Phase_L1, Neutral, ProtectiveEarth | 36
40 | Phase_L1, Neutral, ProtectiveEarth | 36
20 | Phase_L1, Neutral, ProtectiveEarth | 43
33 | Phase_L1, Neutral, ProtectiveEarth | 36
21 | Phase_L1, Neutral, ProtectiveEarth | 43
25 | Phase_L3, Neutral, ProtectiveEarth | 42
41 | Phase_L3, Neutral, ProtectiveEarth | 35 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
36 | Phase_L1, Neutral, ProtectiveEarth | 40
18 | Phase_L1, Neutral, ProtectiveEarth | 33
30 | Phase_L2, Neutral, ProtectiveEarth | 37
24 | Phase_L3, Neutral, ProtectiveEarth | 42
29 | Phase_L2, Neutral, ProtectiveEarth | 37
17 | Phase_L1, Neutral, ProtectiveEarth | 33
19 | Phase_L1, Neutral, ProtectiveEarth | 33
47 | Phase_L1, Neutral, ProtectiveEarth | 33
26 | Phase_L2, Neutral, ProtectiveEarth | 41
22 | Phase_L1, Neutral, ProtectiveEarth | 43
44 | Phase_L2, Neutral, ProtectiveEarth | 34
51 | Phase_L2, Neutral, ProtectiveEarth | 44
35 | Phase_L1, Neutral, ProtectiveEarth | 40
50 | Phase_L2, Neutral, ProtectiveEarth | 44
37 | Phase_L1, Neutral, ProtectiveEarth | 40
49 | Phase_L1, Neutral, ProtectiveEarth | 33
39 | Phase_L1, Neutral, ProtectiveEarth | 36
31 | Phase_L2, Neutral, ProtectiveEarth | 37
45 | Phase_L2, Neutral, ProtectiveEarth | 34
42 | Phase_L3, Neutral, ProtectiveEarth | 35 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
32 | Phase_L1, Neutral, ProtectiveEarth | 36
38 | Phase_L1, Neutral, ProtectiveEarth | 36
23 | Phase_L3, Neutral, ProtectiveEarth | 42
48 | Phase_L1, Neutral, ProtectiveEarth | 33
28 | Phase_L2, Neutral, ProtectiveEarth | 41
27 | Phase_L2, Neutral, ProtectiveEarth | 41
43 | Phase_L3, Neutral, ProtectiveEarth | 35 | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
46 | Phase_L2, Neutral, ProtectiveEarth | 34
64 | Phase_L2, Neutral, ProtectiveEarth | 44
59 | Phase_L1, Neutral, ProtectiveEarth | 36
61 | Phase_L1, Neutral, ProtectiveEarth | 36
63 | Phase_L2, Neutral, ProtectiveEarth | 44
62 | Phase_L2, Neutral, ProtectiveEarth | 44
60 | Phase_L1, Neutral, ProtectiveEarth | 36

# IfcProtectiveDevice: FI-Schalter (RCD) 4-pol. 6kA 40A - 30mA (14)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDF-020606-465; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 40; NumberOfPoles: 0
DDS_Pset_ElectroComponents - Characteristic: 30mA/40A
Name | In | Group
2 x F2 | Obergeschoss | 2
2 x F10 | Obergeschoss | 9
2 x F18 | Obergeschoss | 16
2 x F26 | Obergeschoss | 23
F2 | Erdgeschoss | 2
F10 | Erdgeschoss | 9
F18 | Erdgeschoss | 16
F26 | Erdgeschoss | 23
F35 | Obergeschoss | 32
F43 | Obergeschoss | 39

# IfcProtectiveDevice: FI/LS-Schalter (RCBO) 6kA B10A - 30mA 2-pol. 2TE, F33
In: Obergeschoss
Type - ElementType: RCBO
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDF-020606-489; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 10; NumberOfPoles: 2; ConductorFunction: PHASE_L1, NEUTRAL
DDS_Pset_ElectroComponents - Characteristic: 30mA/B10A
Group: 30

# IfcProtectiveDevice: LS-Schalter (MCB) 6kA B16A 1-pol. 1TE (84)
Type - PredefinedType: CIRCUITBREAKER
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDF-020605-004; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 16; NumberOfPoles: 1; ConductorFunction: PHASE_L1
Type - Pset_ProtectiveDeviceBreakerUnitTypeMCB - NominalCurrents: 16
DDS_Pset_ElectroComponents - Characteristic: B16A
Name | In | Group
2 x F3 | Obergeschoss | 3
2 x F4 | Obergeschoss | 4
2 x F5 | Obergeschoss | 5
2 x F6 | Obergeschoss | 6
2 x F7 | Obergeschoss | 7
2 x F11 | Obergeschoss | 10
2 x F12 | Obergeschoss | 11
2 x F14 | Obergeschoss | 13
2 x F15 | Obergeschoss | 14
2 x F13 | Obergeschoss | 12
2 x F16 | Obergeschoss | 15
2 x F20 | Obergeschoss | 18
2 x F19 | Obergeschoss | 17
2 x F22 | Obergeschoss | 20
2 x F21 | Obergeschoss | 19
2 x F23 | Obergeschoss | 21
2 x F27 | Obergeschoss | 24
2 x F28 | Obergeschoss | 25
2 x F29 | Obergeschoss | 26
2 x F30 | Obergeschoss | 27
2 x F24 | Obergeschoss | 22
2 x F31 | Obergeschoss | 28
2 x F32 | Obergeschoss | 29
2 x F8 | Obergeschoss | 8
F3 | Erdgeschoss | 3
F4 | Erdgeschoss | 4
F5 | Erdgeschoss | 5
F6 | Erdgeschoss | 6
F7 | Erdgeschoss | 7
F8 | Erdgeschoss | 8
F11 | Erdgeschoss | 10
F12 | Erdgeschoss | 11
F13 | Erdgeschoss | 12
F14 | Erdgeschoss | 13
F15 | Erdgeschoss | 14
F16 | Erdgeschoss | 15
F20 | Erdgeschoss | 18
F19 | Erdgeschoss | 17
F22 | Erdgeschoss | 20
F23 | Erdgeschoss | 21
F31 | Erdgeschoss | 28
F29 | Erdgeschoss | 26
F32 | Erdgeschoss | 29
F30 | Erdgeschoss | 27
F28 | Erdgeschoss | 25
F24 | Erdgeschoss | 22
F27 | Erdgeschoss | 24
F21 | Erdgeschoss | 19
F36 | Obergeschoss | 33
F37 | Obergeschoss | 34
F39 | Obergeschoss | 36
F41 | Obergeschoss | 38
F40 | Obergeschoss | 37
F38 | Obergeschoss | 35
F44 | Obergeschoss | 40
F46 | Obergeschoss | 42
F45 | Obergeschoss | 41
F48 | Obergeschoss | 44
F47 | Obergeschoss | 43
F49 | Obergeschoss | 45

# IfcProtectiveDevice: NH - Sicherung 160 / 80A Gr.0 3-pol., F1
In: Untergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDF-020606-231; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 80; NumberOfPoles: 3; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
DDS_Pset_ElectroComponents - Characteristic: NH0/80A
Group: 2

# IfcProtectiveDevice: SLS-Schalter E63A 3-pol. 4,5TE (9)
In: Untergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDF-120508-008; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 63; NumberOfPoles: 3; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
Type - Pset_ProtectiveDeviceBreakerUnitTypeMCB - NominalCurrents: 63
DDS_Pset_ElectroComponents - Characteristic: E63A
Name | Group
F1 | 2
F2 | 3
F3 | 4
F4 | 5
F5 | 6
F6 | 7
F7 | 8
F8 | 9
F9 | 10

# IfcProtectiveDevice: Schmelzsicherung Neozed 35A D02 3-pol. 4,5TE (2)
In: Obergeschoss
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDF-020606-080; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 35; NumberOfPoles: 3; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
DDS_Pset_ElectroComponents - Characteristic: D02/35A
Name | Group
F34 | 32
F42 | 39

# IfcProtectiveDevice: Sicherungs-Lasttrennschalter Neozed 35A D02 3-pol. 4.5TE (12)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDF-040519-038; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 35; NumberOfPoles: 3; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
DDS_Pset_ElectroComponents - Characteristic: D02/35A
Name | In | Group
2 x F1 | Obergeschoss | 2
2 x F9 | Obergeschoss | 9
2 x F17 | Obergeschoss | 16
2 x F25 | Obergeschoss | 23
F1 | Erdgeschoss | 2
F9 | Erdgeschoss | 9
F17 | Erdgeschoss | 16
F25 | Erdgeschoss | 23

# IfcSensor: BMA Rauchmelder, optisch (RMO) (69)
Type - PredefinedType: SMOKESENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E3-020322-001; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Name | In
2 x 70 | Obergeschoss
2 x 69 | Obergeschoss
93 | Obergeschoss
2 x 68 | Obergeschoss
2 x 67 | Obergeschoss
2 x 61 | Obergeschoss
2 x 52 | Obergeschoss
2 x 66 | Obergeschoss
2 x 57 | Obergeschoss
2 x 59 | Obergeschoss
51 | Obergeschoss
49 | Obergeschoss
2 x 50 | Obergeschoss
2 x 64 | Obergeschoss
2 x 53 | Obergeschoss
2 x 60 | Obergeschoss
2 x 63 | Obergeschoss
2 x 65 | Obergeschoss
115 | Erdgeschoss
102 | Erdgeschoss
119 | Erdgeschoss
117 | Erdgeschoss
109 | Erdgeschoss
103 | Erdgeschoss | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
105 | Erdgeschoss
120 | Erdgeschoss
114 | Erdgeschoss
113 | Erdgeschoss
123 | Erdgeschoss
104 | Erdgeschoss
111 | Erdgeschoss
146 | Erdgeschoss
9 x 117 | Untergeschoss
58 | Obergeschoss
2 x 118 | Untergeschoss
113 | Untergeschoss
2 x 115 | Untergeschoss
54 | Obergeschoss
94 | Obergeschoss
55 | Obergeschoss
51 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting
71 | Obergeschoss
62 | Obergeschoss
56 | Obergeschoss

# IfcSensor: BMA Wärmemelder, Maximal- (WMM) (2)
In: Erdgeschoss
Type - PredefinedType: HEATSENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E3-020322-007; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Name
112
147

# IfcSensor: Decken-Präsenzmelder 360° Reichw.ca.Ø 24m (16)
In: Untergeschoss
Type - PredefinedType: MOVEMENTSENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: S2-111118-003; Manufacturer: DDScad
Name
2 x 13
9
2 x 10
6
1
3
4
2
8
7
2 x 11
5
12

# IfcSensor: Decken-Präsenzmelder 360° Reichw.ca.Ø 8m (4)
In: Obergeschoss
Type - PredefinedType: MOVEMENTSENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: S2-111118-001; Manufacturer: DDScad
Group: 6
Name
1
2
4
3

# IfcSensor: EMA Dualmelder (DU) (11)
Type - PredefinedType: MOVEMENTSENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E3-121101-003; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Name | In
3 | Obergeschoss
2 | Obergeschoss
1 | Obergeschoss
2 x 48 | Obergeschoss
47 | Obergeschoss
100 | Erdgeschoss
101 | Erdgeschoss
2 | Erdgeschoss
1 | Erdgeschoss
49 | Obergeschoss

# IfcSensor: KNX Präsenzmelder, Deckenmontage (24)
Type - PredefinedType: MOVEMENTSENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EC-140707-001; Manufacturer: DDScad
Name | In
26 | Obergeschoss
25 | Obergeschoss
2 x 23 | Obergeschoss
2 x 22 | Obergeschoss
2 x 24 | Obergeschoss
21 | Obergeschoss
20 | Obergeschoss
21 | Obergeschoss | Group: 25
22 | Obergeschoss | Group: 24
22 | Erdgeschoss
20 | Obergeschoss | Group: 26
20 | Erdgeschoss
18 | Erdgeschoss
19 | Erdgeschoss
24 | Erdgeschoss
21 | Erdgeschoss
23 | Erdgeschoss
18 | Obergeschoss | Group: 26
17 | Obergeschoss | Group: 26
19 | Obergeschoss | Group: 26
16 | Obergeschoss | Group: 26

# IfcSensor: KNX Tastsensor 4-fach (35)
Type - PredefinedType: CONTACTSENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: EC-031209-004; Manufacturer: DDScad
Name | In
14 | Obergeschoss
6 | Obergeschoss
11 | Obergeschoss
3 | Obergeschoss
8 | Obergeschoss
5 | Obergeschoss
13 | Obergeschoss
17 | Obergeschoss
7 | Obergeschoss
9 | Obergeschoss
16 | Obergeschoss
10 | Obergeschoss
13 | Erdgeschoss
16 | Erdgeschoss
7 | Erdgeschoss
6 | Erdgeschoss
8 | Erdgeschoss
10 | Erdgeschoss
17 | Erdgeschoss
9 | Erdgeschoss
2 | Obergeschoss | Group: 31
7 | Obergeschoss | Group: 31
6 | Obergeschoss | Group: 31
5 | Obergeschoss | Group: 31
11 | Obergeschoss | Group: 31
8 | Obergeschoss | Group: 31
3 | Obergeschoss | Group: 31
4 | Obergeschoss | Group: 31
1 | Obergeschoss | Group: 31
13 | Obergeschoss | Group: 31
10 | Obergeschoss | Group: 31
14 | Obergeschoss | Group: 31
15 | Obergeschoss | Group: 31
12 | Obergeschoss | Group: 31
9 | Obergeschoss | Group: 31

# IfcSensor: Rauchmelder ZD, optisch (RMO) (57)
Type - PredefinedType: SMOKESENSOR
Type - Pset_ManufacturerTypeInformation - ArticleNumber: E3-250523114420; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Name | In
2 x 89 | Obergeschoss
2 x 72 | Obergeschoss
2 x 81 | Obergeschoss
2 x 83 | Obergeschoss
2 x 91 | Obergeschoss
2 x 92 | Obergeschoss
2 x 86 | Obergeschoss
2 x 85 | Obergeschoss
2 x 75 | Obergeschoss
2 x 90 | Obergeschoss
2 x 79 | Obergeschoss
2 x 88 | Obergeschoss
2 x 87 | Obergeschoss
2 x 82 | Obergeschoss
73 | Obergeschoss
94 | Obergeschoss
71 | Obergeschoss
2 x 74 | Obergeschoss
124 | Erdgeschoss
148 | Erdgeschoss
134 | Erdgeschoss
135 | Erdgeschoss
142 | Erdgeschoss
141 | Erdgeschoss
136 | Erdgeschoss
147 | Erdgeschoss
126 | Erdgeschoss
127 | Erdgeschoss
139 | Erdgeschoss
145 | Erdgeschoss
133 | Erdgeschoss
137 | Erdgeschoss
131 | Erdgeschoss
125 | Erdgeschoss | DDS_Pset_RoomPlacement - RoomNumber: 0EG-08; RoomDescription: Cafeteria
80 | Obergeschoss
78 | Obergeschoss
77 | Obergeschoss
95 | Obergeschoss
84 | Obergeschoss
76 | Obergeschoss
93 | Obergeschoss
73 | Obergeschoss | DDS_Pset_RoomPlacement - RoomNumber: 2OG-10; RoomDescription: Meeting

# IfcSolarDevice: PV Modul 1.610 x 861 x 35 mm (252)
In: Dachaufsicht
Type - PredefinedType: SOLARPANEL
Type - Pset_ManufacturerTypeInformation - ArticleNumber: SP-230523135859; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
Name
200
175
190
182
189
185
210
223
206
221
216
226
238
239
174
237
244
532
271
32
272
266
278
280
287
248
27
261
257
253
256
288
251
260
268
29
274
289
265
282
245
533
534
545
277
33
254
2 x 34
249
250
255
28
267
270
273
279
281
283
262
31
286
30
240
243
546
71
74
523
67
68
80
77
73
70
69
78
81
79
76
66
45
65
522
64
37
62
63
61
44
59
72
40
58
50
35
46
39
49
55
36
52
41
53
51
47
43
60
42
56
38
125
48
148
157
154
152
57
156
172
146
171
526
527
169
153
155
147
141
136
131
133
132
170
145
142
166
143
168
134
128
126
127
123
167
130
137
162
144
129
124
151
135
160
161
165
164
158
140
139
524
163
95
116
87
94
100
102
89
90
122
107
120
114
118
91
85
110
115
108
104
150
101
84
98
106
88
97
86
121
83
103
112
113
93
92
109
525
119
105
111
99
149
236
214
82
528
186
227
219
192
181
176
188
22
529
209
183
203
26
194
21
25
202
187
222
217
184
205
215
24
197
199
220
19
231
228
198
191
173
232
20
233
234
204
193
23
177
531
179
530
178

# IfcSwitchingDevice: Hauptschalter 63A 3-pol. (8)
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDS-031022-025; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 63; NumberOfPoles: 3; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
DDS_Pset_ElectroComponents - Characteristic: 63A
Group: 1
Name | In
5 x S1 | Obergeschoss
S1 | Untergeschoss
2 x S1 | Erdgeschoss

# IfcTransformer: KNX Spannungsversorgung mit Drossel 160mA REG 4 TE, A1
In: Obergeschoss
Type - PredefinedType: VOLTAGE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: FDA-120216-001; Manufacturer: DDScad
Type - Pset_ElectricalDeviceCommon - RatedCurrent: any to 0; NumberOfPoles: 4204; ConductorFunction: PHASE_L1, PHASE_L2, PHASE_L3
DDS_Pset_ElectroComponents - Characteristic: 0A
Group: 30
